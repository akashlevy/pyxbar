.title <test_1R_cb5pt_16x16_2f>

** Includes **

** Load models **
.hdl ../models/rram_wp_akash.va

** Options **
.option post=2
.option probe

** Parameters **

** Probes **
.probe V(gap_0_0, col_0_0)
.probe V(gap_0_1, col_0_1)
.probe V(gap_0_2, col_0_2)
.probe V(gap_1_0, col_1_0)
.probe V(gap_1_1, col_1_1)
.probe V(gap_1_2, col_1_2)
.probe V(gap_2_0, col_2_0)
.probe V(gap_2_1, col_2_1)
.probe V(gap_2_2, col_2_2)
.probe V(gap_0_13, col_0_13)
.probe V(gap_0_14, col_0_14)
.probe V(gap_0_15, col_0_15)
.probe V(gap_1_13, col_1_13)
.probe V(gap_1_14, col_1_14)
.probe V(gap_1_15, col_1_15)
.probe V(gap_2_13, col_2_13)
.probe V(gap_2_14, col_2_14)
.probe V(gap_2_15, col_2_15)
.probe V(gap_7_7, col_7_7)
.probe V(gap_7_8, col_7_8)
.probe V(gap_8_7, col_8_7)
.probe V(gap_8_8, col_8_8)
.probe V(gap_13_0, col_13_0)
.probe V(gap_13_1, col_13_1)
.probe V(gap_13_2, col_13_2)
.probe V(gap_14_0, col_14_0)
.probe V(gap_14_1, col_14_1)
.probe V(gap_14_2, col_14_2)
.probe V(gap_15_0, col_15_0)
.probe V(gap_15_1, col_15_1)
.probe V(gap_15_2, col_15_2)
.probe V(gap_13_13, col_13_13)
.probe V(gap_13_14, col_13_14)
.probe V(gap_13_15, col_13_15)
.probe V(gap_14_13, col_14_13)
.probe V(gap_14_14, col_14_14)
.probe V(gap_14_15, col_14_15)
.probe V(gap_15_13, col_15_13)
.probe V(gap_15_14, col_15_14)
.probe V(gap_15_15, col_15_15)
.probe V(row_0_0)
.probe V(row_1_0)
.probe V(row_2_0)
.probe V(row_3_0)
.probe V(row_4_0)
.probe V(row_5_0)
.probe V(row_6_0)
.probe V(row_7_0)
.probe V(row_8_0)
.probe V(row_9_0)
.probe V(row_10_0)
.probe V(row_11_0)
.probe V(row_12_0)
.probe V(row_13_0)
.probe V(row_14_0)
.probe V(row_15_0)
.probe V(col_0_0)
.probe V(col_0_1)
.probe V(col_0_2)
.probe V(col_0_3)
.probe V(col_0_4)
.probe V(col_0_5)
.probe V(col_0_6)
.probe V(col_0_7)
.probe V(col_0_8)
.probe V(col_0_9)
.probe V(col_0_10)
.probe V(col_0_11)
.probe V(col_0_12)
.probe V(col_0_13)
.probe V(col_0_14)
.probe V(col_0_15)
.probe I(Vrow_0)
.probe I(Vrow_1)
.probe I(Vrow_2)
.probe I(Vrow_3)
.probe I(Vrow_4)
.probe I(Vrow_5)
.probe I(Vrow_6)
.probe I(Vrow_7)
.probe I(Vrow_8)
.probe I(Vrow_9)
.probe I(Vrow_10)
.probe I(Vrow_11)
.probe I(Vrow_12)
.probe I(Vrow_13)
.probe I(Vrow_14)
.probe I(Vrow_15)
.probe I(Vcol_0)
.probe I(Vcol_1)
.probe I(Vcol_2)
.probe I(Vcol_3)
.probe I(Vcol_4)
.probe I(Vcol_5)
.probe I(Vcol_6)
.probe I(Vcol_7)
.probe I(Vcol_8)
.probe I(Vcol_9)
.probe I(Vcol_10)
.probe I(Vcol_11)
.probe I(Vcol_12)
.probe I(Vcol_13)
.probe I(Vcol_14)
.probe I(Vcol_15)

** Sub-circuits **
.subckt CELL r1 r2 c1 c2 gap
Rr r1 r2 0.18
Cr r1 gnd 1.08e-13
Rc c1 c2 0.18
Cc c1 gnd 1.08e-13
X1 r1 c1 gap RRAM_v0
.ends CELL

** Crossbar instantiation **
Xcell_0_0 row_0_0 row_0_1 col_0_0 col_1_0 gap_0_0 CELL
.ic v(gap_0_0)=0.85
Xcell_0_1 row_0_1 row_0_2 col_0_1 col_1_1 gap_0_1 CELL
.ic v(gap_0_1)=0.85
Xcell_0_2 row_0_2 row_0_3 col_0_2 col_1_2 gap_0_2 CELL
.ic v(gap_0_2)=0.85
Xcell_0_3 row_0_3 row_0_4 col_0_3 col_1_3 gap_0_3 CELL
.ic v(gap_0_3)=0.85
Xcell_0_4 row_0_4 row_0_5 col_0_4 col_1_4 gap_0_4 CELL
.ic v(gap_0_4)=0.85
Xcell_0_5 row_0_5 row_0_6 col_0_5 col_1_5 gap_0_5 CELL
.ic v(gap_0_5)=0.85
Xcell_0_6 row_0_6 row_0_7 col_0_6 col_1_6 gap_0_6 CELL
.ic v(gap_0_6)=0.85
Xcell_0_7 row_0_7 row_0_8 col_0_7 col_1_7 gap_0_7 CELL
.ic v(gap_0_7)=0.85
Xcell_0_8 row_0_8 row_0_9 col_0_8 col_1_8 gap_0_8 CELL
.ic v(gap_0_8)=0.85
Xcell_0_9 row_0_9 row_0_10 col_0_9 col_1_9 gap_0_9 CELL
.ic v(gap_0_9)=0.85
Xcell_0_10 row_0_10 row_0_11 col_0_10 col_1_10 gap_0_10 CELL
.ic v(gap_0_10)=0.85
Xcell_0_11 row_0_11 row_0_12 col_0_11 col_1_11 gap_0_11 CELL
.ic v(gap_0_11)=0.85
Xcell_0_12 row_0_12 row_0_13 col_0_12 col_1_12 gap_0_12 CELL
.ic v(gap_0_12)=0.85
Xcell_0_13 row_0_13 row_0_14 col_0_13 col_1_13 gap_0_13 CELL
.ic v(gap_0_13)=0.85
Xcell_0_14 row_0_14 row_0_15 col_0_14 col_1_14 gap_0_14 CELL
.ic v(gap_0_14)=0.85
Xcell_0_15 row_0_15 row_0_16 col_0_15 col_1_15 gap_0_15 CELL
.ic v(gap_0_15)=0.85
Xcell_1_0 row_1_0 row_1_1 col_1_0 col_2_0 gap_1_0 CELL
.ic v(gap_1_0)=0.85
Xcell_1_1 row_1_1 row_1_2 col_1_1 col_2_1 gap_1_1 CELL
.ic v(gap_1_1)=0.85
Xcell_1_2 row_1_2 row_1_3 col_1_2 col_2_2 gap_1_2 CELL
.ic v(gap_1_2)=0.85
Xcell_1_3 row_1_3 row_1_4 col_1_3 col_2_3 gap_1_3 CELL
.ic v(gap_1_3)=0.85
Xcell_1_4 row_1_4 row_1_5 col_1_4 col_2_4 gap_1_4 CELL
.ic v(gap_1_4)=0.85
Xcell_1_5 row_1_5 row_1_6 col_1_5 col_2_5 gap_1_5 CELL
.ic v(gap_1_5)=0.85
Xcell_1_6 row_1_6 row_1_7 col_1_6 col_2_6 gap_1_6 CELL
.ic v(gap_1_6)=0.85
Xcell_1_7 row_1_7 row_1_8 col_1_7 col_2_7 gap_1_7 CELL
.ic v(gap_1_7)=0.85
Xcell_1_8 row_1_8 row_1_9 col_1_8 col_2_8 gap_1_8 CELL
.ic v(gap_1_8)=0.85
Xcell_1_9 row_1_9 row_1_10 col_1_9 col_2_9 gap_1_9 CELL
.ic v(gap_1_9)=0.85
Xcell_1_10 row_1_10 row_1_11 col_1_10 col_2_10 gap_1_10 CELL
.ic v(gap_1_10)=0.85
Xcell_1_11 row_1_11 row_1_12 col_1_11 col_2_11 gap_1_11 CELL
.ic v(gap_1_11)=0.85
Xcell_1_12 row_1_12 row_1_13 col_1_12 col_2_12 gap_1_12 CELL
.ic v(gap_1_12)=0.85
Xcell_1_13 row_1_13 row_1_14 col_1_13 col_2_13 gap_1_13 CELL
.ic v(gap_1_13)=0.85
Xcell_1_14 row_1_14 row_1_15 col_1_14 col_2_14 gap_1_14 CELL
.ic v(gap_1_14)=0.85
Xcell_1_15 row_1_15 row_1_16 col_1_15 col_2_15 gap_1_15 CELL
.ic v(gap_1_15)=0.85
Xcell_2_0 row_2_0 row_2_1 col_2_0 col_3_0 gap_2_0 CELL
.ic v(gap_2_0)=0.85
Xcell_2_1 row_2_1 row_2_2 col_2_1 col_3_1 gap_2_1 CELL
.ic v(gap_2_1)=0.85
Xcell_2_2 row_2_2 row_2_3 col_2_2 col_3_2 gap_2_2 CELL
.ic v(gap_2_2)=0.85
Xcell_2_3 row_2_3 row_2_4 col_2_3 col_3_3 gap_2_3 CELL
.ic v(gap_2_3)=0.85
Xcell_2_4 row_2_4 row_2_5 col_2_4 col_3_4 gap_2_4 CELL
.ic v(gap_2_4)=0.85
Xcell_2_5 row_2_5 row_2_6 col_2_5 col_3_5 gap_2_5 CELL
.ic v(gap_2_5)=0.85
Xcell_2_6 row_2_6 row_2_7 col_2_6 col_3_6 gap_2_6 CELL
.ic v(gap_2_6)=0.85
Xcell_2_7 row_2_7 row_2_8 col_2_7 col_3_7 gap_2_7 CELL
.ic v(gap_2_7)=0.85
Xcell_2_8 row_2_8 row_2_9 col_2_8 col_3_8 gap_2_8 CELL
.ic v(gap_2_8)=0.85
Xcell_2_9 row_2_9 row_2_10 col_2_9 col_3_9 gap_2_9 CELL
.ic v(gap_2_9)=0.85
Xcell_2_10 row_2_10 row_2_11 col_2_10 col_3_10 gap_2_10 CELL
.ic v(gap_2_10)=0.85
Xcell_2_11 row_2_11 row_2_12 col_2_11 col_3_11 gap_2_11 CELL
.ic v(gap_2_11)=0.85
Xcell_2_12 row_2_12 row_2_13 col_2_12 col_3_12 gap_2_12 CELL
.ic v(gap_2_12)=0.85
Xcell_2_13 row_2_13 row_2_14 col_2_13 col_3_13 gap_2_13 CELL
.ic v(gap_2_13)=0.85
Xcell_2_14 row_2_14 row_2_15 col_2_14 col_3_14 gap_2_14 CELL
.ic v(gap_2_14)=0.85
Xcell_2_15 row_2_15 row_2_16 col_2_15 col_3_15 gap_2_15 CELL
.ic v(gap_2_15)=0.85
Xcell_3_0 row_3_0 row_3_1 col_3_0 col_4_0 gap_3_0 CELL
.ic v(gap_3_0)=0.85
Xcell_3_1 row_3_1 row_3_2 col_3_1 col_4_1 gap_3_1 CELL
.ic v(gap_3_1)=0.85
Xcell_3_2 row_3_2 row_3_3 col_3_2 col_4_2 gap_3_2 CELL
.ic v(gap_3_2)=0.85
Xcell_3_3 row_3_3 row_3_4 col_3_3 col_4_3 gap_3_3 CELL
.ic v(gap_3_3)=0.85
Xcell_3_4 row_3_4 row_3_5 col_3_4 col_4_4 gap_3_4 CELL
.ic v(gap_3_4)=0.85
Xcell_3_5 row_3_5 row_3_6 col_3_5 col_4_5 gap_3_5 CELL
.ic v(gap_3_5)=0.85
Xcell_3_6 row_3_6 row_3_7 col_3_6 col_4_6 gap_3_6 CELL
.ic v(gap_3_6)=0.85
Xcell_3_7 row_3_7 row_3_8 col_3_7 col_4_7 gap_3_7 CELL
.ic v(gap_3_7)=0.85
Xcell_3_8 row_3_8 row_3_9 col_3_8 col_4_8 gap_3_8 CELL
.ic v(gap_3_8)=0.85
Xcell_3_9 row_3_9 row_3_10 col_3_9 col_4_9 gap_3_9 CELL
.ic v(gap_3_9)=0.85
Xcell_3_10 row_3_10 row_3_11 col_3_10 col_4_10 gap_3_10 CELL
.ic v(gap_3_10)=0.85
Xcell_3_11 row_3_11 row_3_12 col_3_11 col_4_11 gap_3_11 CELL
.ic v(gap_3_11)=0.85
Xcell_3_12 row_3_12 row_3_13 col_3_12 col_4_12 gap_3_12 CELL
.ic v(gap_3_12)=0.85
Xcell_3_13 row_3_13 row_3_14 col_3_13 col_4_13 gap_3_13 CELL
.ic v(gap_3_13)=0.85
Xcell_3_14 row_3_14 row_3_15 col_3_14 col_4_14 gap_3_14 CELL
.ic v(gap_3_14)=0.85
Xcell_3_15 row_3_15 row_3_16 col_3_15 col_4_15 gap_3_15 CELL
.ic v(gap_3_15)=0.85
Xcell_4_0 row_4_0 row_4_1 col_4_0 col_5_0 gap_4_0 CELL
.ic v(gap_4_0)=0.85
Xcell_4_1 row_4_1 row_4_2 col_4_1 col_5_1 gap_4_1 CELL
.ic v(gap_4_1)=0.85
Xcell_4_2 row_4_2 row_4_3 col_4_2 col_5_2 gap_4_2 CELL
.ic v(gap_4_2)=0.85
Xcell_4_3 row_4_3 row_4_4 col_4_3 col_5_3 gap_4_3 CELL
.ic v(gap_4_3)=0.85
Xcell_4_4 row_4_4 row_4_5 col_4_4 col_5_4 gap_4_4 CELL
.ic v(gap_4_4)=0.85
Xcell_4_5 row_4_5 row_4_6 col_4_5 col_5_5 gap_4_5 CELL
.ic v(gap_4_5)=0.85
Xcell_4_6 row_4_6 row_4_7 col_4_6 col_5_6 gap_4_6 CELL
.ic v(gap_4_6)=0.85
Xcell_4_7 row_4_7 row_4_8 col_4_7 col_5_7 gap_4_7 CELL
.ic v(gap_4_7)=0.85
Xcell_4_8 row_4_8 row_4_9 col_4_8 col_5_8 gap_4_8 CELL
.ic v(gap_4_8)=0.85
Xcell_4_9 row_4_9 row_4_10 col_4_9 col_5_9 gap_4_9 CELL
.ic v(gap_4_9)=0.85
Xcell_4_10 row_4_10 row_4_11 col_4_10 col_5_10 gap_4_10 CELL
.ic v(gap_4_10)=0.85
Xcell_4_11 row_4_11 row_4_12 col_4_11 col_5_11 gap_4_11 CELL
.ic v(gap_4_11)=0.85
Xcell_4_12 row_4_12 row_4_13 col_4_12 col_5_12 gap_4_12 CELL
.ic v(gap_4_12)=0.85
Xcell_4_13 row_4_13 row_4_14 col_4_13 col_5_13 gap_4_13 CELL
.ic v(gap_4_13)=0.85
Xcell_4_14 row_4_14 row_4_15 col_4_14 col_5_14 gap_4_14 CELL
.ic v(gap_4_14)=0.85
Xcell_4_15 row_4_15 row_4_16 col_4_15 col_5_15 gap_4_15 CELL
.ic v(gap_4_15)=0.85
Xcell_5_0 row_5_0 row_5_1 col_5_0 col_6_0 gap_5_0 CELL
.ic v(gap_5_0)=0.85
Xcell_5_1 row_5_1 row_5_2 col_5_1 col_6_1 gap_5_1 CELL
.ic v(gap_5_1)=0.85
Xcell_5_2 row_5_2 row_5_3 col_5_2 col_6_2 gap_5_2 CELL
.ic v(gap_5_2)=0.85
Xcell_5_3 row_5_3 row_5_4 col_5_3 col_6_3 gap_5_3 CELL
.ic v(gap_5_3)=0.85
Xcell_5_4 row_5_4 row_5_5 col_5_4 col_6_4 gap_5_4 CELL
.ic v(gap_5_4)=0.85
Xcell_5_5 row_5_5 row_5_6 col_5_5 col_6_5 gap_5_5 CELL
.ic v(gap_5_5)=0.85
Xcell_5_6 row_5_6 row_5_7 col_5_6 col_6_6 gap_5_6 CELL
.ic v(gap_5_6)=0.85
Xcell_5_7 row_5_7 row_5_8 col_5_7 col_6_7 gap_5_7 CELL
.ic v(gap_5_7)=0.85
Xcell_5_8 row_5_8 row_5_9 col_5_8 col_6_8 gap_5_8 CELL
.ic v(gap_5_8)=0.85
Xcell_5_9 row_5_9 row_5_10 col_5_9 col_6_9 gap_5_9 CELL
.ic v(gap_5_9)=0.85
Xcell_5_10 row_5_10 row_5_11 col_5_10 col_6_10 gap_5_10 CELL
.ic v(gap_5_10)=0.85
Xcell_5_11 row_5_11 row_5_12 col_5_11 col_6_11 gap_5_11 CELL
.ic v(gap_5_11)=0.85
Xcell_5_12 row_5_12 row_5_13 col_5_12 col_6_12 gap_5_12 CELL
.ic v(gap_5_12)=0.85
Xcell_5_13 row_5_13 row_5_14 col_5_13 col_6_13 gap_5_13 CELL
.ic v(gap_5_13)=0.85
Xcell_5_14 row_5_14 row_5_15 col_5_14 col_6_14 gap_5_14 CELL
.ic v(gap_5_14)=0.85
Xcell_5_15 row_5_15 row_5_16 col_5_15 col_6_15 gap_5_15 CELL
.ic v(gap_5_15)=0.85
Xcell_6_0 row_6_0 row_6_1 col_6_0 col_7_0 gap_6_0 CELL
.ic v(gap_6_0)=0.85
Xcell_6_1 row_6_1 row_6_2 col_6_1 col_7_1 gap_6_1 CELL
.ic v(gap_6_1)=0.85
Xcell_6_2 row_6_2 row_6_3 col_6_2 col_7_2 gap_6_2 CELL
.ic v(gap_6_2)=0.85
Xcell_6_3 row_6_3 row_6_4 col_6_3 col_7_3 gap_6_3 CELL
.ic v(gap_6_3)=0.85
Xcell_6_4 row_6_4 row_6_5 col_6_4 col_7_4 gap_6_4 CELL
.ic v(gap_6_4)=0.85
Xcell_6_5 row_6_5 row_6_6 col_6_5 col_7_5 gap_6_5 CELL
.ic v(gap_6_5)=0.85
Xcell_6_6 row_6_6 row_6_7 col_6_6 col_7_6 gap_6_6 CELL
.ic v(gap_6_6)=0.85
Xcell_6_7 row_6_7 row_6_8 col_6_7 col_7_7 gap_6_7 CELL
.ic v(gap_6_7)=0.85
Xcell_6_8 row_6_8 row_6_9 col_6_8 col_7_8 gap_6_8 CELL
.ic v(gap_6_8)=0.85
Xcell_6_9 row_6_9 row_6_10 col_6_9 col_7_9 gap_6_9 CELL
.ic v(gap_6_9)=0.85
Xcell_6_10 row_6_10 row_6_11 col_6_10 col_7_10 gap_6_10 CELL
.ic v(gap_6_10)=0.85
Xcell_6_11 row_6_11 row_6_12 col_6_11 col_7_11 gap_6_11 CELL
.ic v(gap_6_11)=0.85
Xcell_6_12 row_6_12 row_6_13 col_6_12 col_7_12 gap_6_12 CELL
.ic v(gap_6_12)=0.85
Xcell_6_13 row_6_13 row_6_14 col_6_13 col_7_13 gap_6_13 CELL
.ic v(gap_6_13)=0.85
Xcell_6_14 row_6_14 row_6_15 col_6_14 col_7_14 gap_6_14 CELL
.ic v(gap_6_14)=0.85
Xcell_6_15 row_6_15 row_6_16 col_6_15 col_7_15 gap_6_15 CELL
.ic v(gap_6_15)=0.85
Xcell_7_0 row_7_0 row_7_1 col_7_0 col_8_0 gap_7_0 CELL
.ic v(gap_7_0)=0.85
Xcell_7_1 row_7_1 row_7_2 col_7_1 col_8_1 gap_7_1 CELL
.ic v(gap_7_1)=0.85
Xcell_7_2 row_7_2 row_7_3 col_7_2 col_8_2 gap_7_2 CELL
.ic v(gap_7_2)=0.85
Xcell_7_3 row_7_3 row_7_4 col_7_3 col_8_3 gap_7_3 CELL
.ic v(gap_7_3)=0.85
Xcell_7_4 row_7_4 row_7_5 col_7_4 col_8_4 gap_7_4 CELL
.ic v(gap_7_4)=0.85
Xcell_7_5 row_7_5 row_7_6 col_7_5 col_8_5 gap_7_5 CELL
.ic v(gap_7_5)=0.85
Xcell_7_6 row_7_6 row_7_7 col_7_6 col_8_6 gap_7_6 CELL
.ic v(gap_7_6)=0.85
Xcell_7_7 row_7_7 row_7_8 col_7_7 col_8_7 gap_7_7 CELL
.ic v(gap_7_7)=0.85
Xcell_7_8 row_7_8 row_7_9 col_7_8 col_8_8 gap_7_8 CELL
.ic v(gap_7_8)=0.85
Xcell_7_9 row_7_9 row_7_10 col_7_9 col_8_9 gap_7_9 CELL
.ic v(gap_7_9)=0.85
Xcell_7_10 row_7_10 row_7_11 col_7_10 col_8_10 gap_7_10 CELL
.ic v(gap_7_10)=0.85
Xcell_7_11 row_7_11 row_7_12 col_7_11 col_8_11 gap_7_11 CELL
.ic v(gap_7_11)=0.85
Xcell_7_12 row_7_12 row_7_13 col_7_12 col_8_12 gap_7_12 CELL
.ic v(gap_7_12)=0.85
Xcell_7_13 row_7_13 row_7_14 col_7_13 col_8_13 gap_7_13 CELL
.ic v(gap_7_13)=0.85
Xcell_7_14 row_7_14 row_7_15 col_7_14 col_8_14 gap_7_14 CELL
.ic v(gap_7_14)=0.85
Xcell_7_15 row_7_15 row_7_16 col_7_15 col_8_15 gap_7_15 CELL
.ic v(gap_7_15)=0.85
Xcell_8_0 row_8_0 row_8_1 col_8_0 col_9_0 gap_8_0 CELL
.ic v(gap_8_0)=0.85
Xcell_8_1 row_8_1 row_8_2 col_8_1 col_9_1 gap_8_1 CELL
.ic v(gap_8_1)=0.85
Xcell_8_2 row_8_2 row_8_3 col_8_2 col_9_2 gap_8_2 CELL
.ic v(gap_8_2)=0.85
Xcell_8_3 row_8_3 row_8_4 col_8_3 col_9_3 gap_8_3 CELL
.ic v(gap_8_3)=0.85
Xcell_8_4 row_8_4 row_8_5 col_8_4 col_9_4 gap_8_4 CELL
.ic v(gap_8_4)=0.85
Xcell_8_5 row_8_5 row_8_6 col_8_5 col_9_5 gap_8_5 CELL
.ic v(gap_8_5)=0.85
Xcell_8_6 row_8_6 row_8_7 col_8_6 col_9_6 gap_8_6 CELL
.ic v(gap_8_6)=0.85
Xcell_8_7 row_8_7 row_8_8 col_8_7 col_9_7 gap_8_7 CELL
.ic v(gap_8_7)=0.85
Xcell_8_8 row_8_8 row_8_9 col_8_8 col_9_8 gap_8_8 CELL
.ic v(gap_8_8)=0.85
Xcell_8_9 row_8_9 row_8_10 col_8_9 col_9_9 gap_8_9 CELL
.ic v(gap_8_9)=0.85
Xcell_8_10 row_8_10 row_8_11 col_8_10 col_9_10 gap_8_10 CELL
.ic v(gap_8_10)=0.85
Xcell_8_11 row_8_11 row_8_12 col_8_11 col_9_11 gap_8_11 CELL
.ic v(gap_8_11)=0.85
Xcell_8_12 row_8_12 row_8_13 col_8_12 col_9_12 gap_8_12 CELL
.ic v(gap_8_12)=0.85
Xcell_8_13 row_8_13 row_8_14 col_8_13 col_9_13 gap_8_13 CELL
.ic v(gap_8_13)=0.85
Xcell_8_14 row_8_14 row_8_15 col_8_14 col_9_14 gap_8_14 CELL
.ic v(gap_8_14)=0.85
Xcell_8_15 row_8_15 row_8_16 col_8_15 col_9_15 gap_8_15 CELL
.ic v(gap_8_15)=0.85
Xcell_9_0 row_9_0 row_9_1 col_9_0 col_10_0 gap_9_0 CELL
.ic v(gap_9_0)=0.85
Xcell_9_1 row_9_1 row_9_2 col_9_1 col_10_1 gap_9_1 CELL
.ic v(gap_9_1)=0.85
Xcell_9_2 row_9_2 row_9_3 col_9_2 col_10_2 gap_9_2 CELL
.ic v(gap_9_2)=0.85
Xcell_9_3 row_9_3 row_9_4 col_9_3 col_10_3 gap_9_3 CELL
.ic v(gap_9_3)=0.85
Xcell_9_4 row_9_4 row_9_5 col_9_4 col_10_4 gap_9_4 CELL
.ic v(gap_9_4)=0.85
Xcell_9_5 row_9_5 row_9_6 col_9_5 col_10_5 gap_9_5 CELL
.ic v(gap_9_5)=0.85
Xcell_9_6 row_9_6 row_9_7 col_9_6 col_10_6 gap_9_6 CELL
.ic v(gap_9_6)=0.85
Xcell_9_7 row_9_7 row_9_8 col_9_7 col_10_7 gap_9_7 CELL
.ic v(gap_9_7)=0.85
Xcell_9_8 row_9_8 row_9_9 col_9_8 col_10_8 gap_9_8 CELL
.ic v(gap_9_8)=0.85
Xcell_9_9 row_9_9 row_9_10 col_9_9 col_10_9 gap_9_9 CELL
.ic v(gap_9_9)=0.85
Xcell_9_10 row_9_10 row_9_11 col_9_10 col_10_10 gap_9_10 CELL
.ic v(gap_9_10)=0.85
Xcell_9_11 row_9_11 row_9_12 col_9_11 col_10_11 gap_9_11 CELL
.ic v(gap_9_11)=0.85
Xcell_9_12 row_9_12 row_9_13 col_9_12 col_10_12 gap_9_12 CELL
.ic v(gap_9_12)=0.85
Xcell_9_13 row_9_13 row_9_14 col_9_13 col_10_13 gap_9_13 CELL
.ic v(gap_9_13)=0.85
Xcell_9_14 row_9_14 row_9_15 col_9_14 col_10_14 gap_9_14 CELL
.ic v(gap_9_14)=0.85
Xcell_9_15 row_9_15 row_9_16 col_9_15 col_10_15 gap_9_15 CELL
.ic v(gap_9_15)=0.85
Xcell_10_0 row_10_0 row_10_1 col_10_0 col_11_0 gap_10_0 CELL
.ic v(gap_10_0)=0.85
Xcell_10_1 row_10_1 row_10_2 col_10_1 col_11_1 gap_10_1 CELL
.ic v(gap_10_1)=0.85
Xcell_10_2 row_10_2 row_10_3 col_10_2 col_11_2 gap_10_2 CELL
.ic v(gap_10_2)=0.85
Xcell_10_3 row_10_3 row_10_4 col_10_3 col_11_3 gap_10_3 CELL
.ic v(gap_10_3)=0.85
Xcell_10_4 row_10_4 row_10_5 col_10_4 col_11_4 gap_10_4 CELL
.ic v(gap_10_4)=0.85
Xcell_10_5 row_10_5 row_10_6 col_10_5 col_11_5 gap_10_5 CELL
.ic v(gap_10_5)=0.85
Xcell_10_6 row_10_6 row_10_7 col_10_6 col_11_6 gap_10_6 CELL
.ic v(gap_10_6)=0.85
Xcell_10_7 row_10_7 row_10_8 col_10_7 col_11_7 gap_10_7 CELL
.ic v(gap_10_7)=0.85
Xcell_10_8 row_10_8 row_10_9 col_10_8 col_11_8 gap_10_8 CELL
.ic v(gap_10_8)=0.85
Xcell_10_9 row_10_9 row_10_10 col_10_9 col_11_9 gap_10_9 CELL
.ic v(gap_10_9)=0.85
Xcell_10_10 row_10_10 row_10_11 col_10_10 col_11_10 gap_10_10 CELL
.ic v(gap_10_10)=0.85
Xcell_10_11 row_10_11 row_10_12 col_10_11 col_11_11 gap_10_11 CELL
.ic v(gap_10_11)=0.85
Xcell_10_12 row_10_12 row_10_13 col_10_12 col_11_12 gap_10_12 CELL
.ic v(gap_10_12)=0.85
Xcell_10_13 row_10_13 row_10_14 col_10_13 col_11_13 gap_10_13 CELL
.ic v(gap_10_13)=0.85
Xcell_10_14 row_10_14 row_10_15 col_10_14 col_11_14 gap_10_14 CELL
.ic v(gap_10_14)=0.85
Xcell_10_15 row_10_15 row_10_16 col_10_15 col_11_15 gap_10_15 CELL
.ic v(gap_10_15)=0.85
Xcell_11_0 row_11_0 row_11_1 col_11_0 col_12_0 gap_11_0 CELL
.ic v(gap_11_0)=0.85
Xcell_11_1 row_11_1 row_11_2 col_11_1 col_12_1 gap_11_1 CELL
.ic v(gap_11_1)=0.85
Xcell_11_2 row_11_2 row_11_3 col_11_2 col_12_2 gap_11_2 CELL
.ic v(gap_11_2)=0.85
Xcell_11_3 row_11_3 row_11_4 col_11_3 col_12_3 gap_11_3 CELL
.ic v(gap_11_3)=0.85
Xcell_11_4 row_11_4 row_11_5 col_11_4 col_12_4 gap_11_4 CELL
.ic v(gap_11_4)=0.85
Xcell_11_5 row_11_5 row_11_6 col_11_5 col_12_5 gap_11_5 CELL
.ic v(gap_11_5)=0.85
Xcell_11_6 row_11_6 row_11_7 col_11_6 col_12_6 gap_11_6 CELL
.ic v(gap_11_6)=0.85
Xcell_11_7 row_11_7 row_11_8 col_11_7 col_12_7 gap_11_7 CELL
.ic v(gap_11_7)=0.85
Xcell_11_8 row_11_8 row_11_9 col_11_8 col_12_8 gap_11_8 CELL
.ic v(gap_11_8)=0.85
Xcell_11_9 row_11_9 row_11_10 col_11_9 col_12_9 gap_11_9 CELL
.ic v(gap_11_9)=0.85
Xcell_11_10 row_11_10 row_11_11 col_11_10 col_12_10 gap_11_10 CELL
.ic v(gap_11_10)=0.85
Xcell_11_11 row_11_11 row_11_12 col_11_11 col_12_11 gap_11_11 CELL
.ic v(gap_11_11)=0.85
Xcell_11_12 row_11_12 row_11_13 col_11_12 col_12_12 gap_11_12 CELL
.ic v(gap_11_12)=0.85
Xcell_11_13 row_11_13 row_11_14 col_11_13 col_12_13 gap_11_13 CELL
.ic v(gap_11_13)=0.85
Xcell_11_14 row_11_14 row_11_15 col_11_14 col_12_14 gap_11_14 CELL
.ic v(gap_11_14)=0.85
Xcell_11_15 row_11_15 row_11_16 col_11_15 col_12_15 gap_11_15 CELL
.ic v(gap_11_15)=0.85
Xcell_12_0 row_12_0 row_12_1 col_12_0 col_13_0 gap_12_0 CELL
.ic v(gap_12_0)=0.85
Xcell_12_1 row_12_1 row_12_2 col_12_1 col_13_1 gap_12_1 CELL
.ic v(gap_12_1)=0.85
Xcell_12_2 row_12_2 row_12_3 col_12_2 col_13_2 gap_12_2 CELL
.ic v(gap_12_2)=0.85
Xcell_12_3 row_12_3 row_12_4 col_12_3 col_13_3 gap_12_3 CELL
.ic v(gap_12_3)=0.85
Xcell_12_4 row_12_4 row_12_5 col_12_4 col_13_4 gap_12_4 CELL
.ic v(gap_12_4)=0.85
Xcell_12_5 row_12_5 row_12_6 col_12_5 col_13_5 gap_12_5 CELL
.ic v(gap_12_5)=0.85
Xcell_12_6 row_12_6 row_12_7 col_12_6 col_13_6 gap_12_6 CELL
.ic v(gap_12_6)=0.85
Xcell_12_7 row_12_7 row_12_8 col_12_7 col_13_7 gap_12_7 CELL
.ic v(gap_12_7)=0.85
Xcell_12_8 row_12_8 row_12_9 col_12_8 col_13_8 gap_12_8 CELL
.ic v(gap_12_8)=0.85
Xcell_12_9 row_12_9 row_12_10 col_12_9 col_13_9 gap_12_9 CELL
.ic v(gap_12_9)=0.85
Xcell_12_10 row_12_10 row_12_11 col_12_10 col_13_10 gap_12_10 CELL
.ic v(gap_12_10)=0.85
Xcell_12_11 row_12_11 row_12_12 col_12_11 col_13_11 gap_12_11 CELL
.ic v(gap_12_11)=0.85
Xcell_12_12 row_12_12 row_12_13 col_12_12 col_13_12 gap_12_12 CELL
.ic v(gap_12_12)=0.85
Xcell_12_13 row_12_13 row_12_14 col_12_13 col_13_13 gap_12_13 CELL
.ic v(gap_12_13)=0.85
Xcell_12_14 row_12_14 row_12_15 col_12_14 col_13_14 gap_12_14 CELL
.ic v(gap_12_14)=0.85
Xcell_12_15 row_12_15 row_12_16 col_12_15 col_13_15 gap_12_15 CELL
.ic v(gap_12_15)=0.85
Xcell_13_0 row_13_0 row_13_1 col_13_0 col_14_0 gap_13_0 CELL
.ic v(gap_13_0)=0.85
Xcell_13_1 row_13_1 row_13_2 col_13_1 col_14_1 gap_13_1 CELL
.ic v(gap_13_1)=0.85
Xcell_13_2 row_13_2 row_13_3 col_13_2 col_14_2 gap_13_2 CELL
.ic v(gap_13_2)=0.85
Xcell_13_3 row_13_3 row_13_4 col_13_3 col_14_3 gap_13_3 CELL
.ic v(gap_13_3)=0.85
Xcell_13_4 row_13_4 row_13_5 col_13_4 col_14_4 gap_13_4 CELL
.ic v(gap_13_4)=0.85
Xcell_13_5 row_13_5 row_13_6 col_13_5 col_14_5 gap_13_5 CELL
.ic v(gap_13_5)=0.85
Xcell_13_6 row_13_6 row_13_7 col_13_6 col_14_6 gap_13_6 CELL
.ic v(gap_13_6)=0.85
Xcell_13_7 row_13_7 row_13_8 col_13_7 col_14_7 gap_13_7 CELL
.ic v(gap_13_7)=0.85
Xcell_13_8 row_13_8 row_13_9 col_13_8 col_14_8 gap_13_8 CELL
.ic v(gap_13_8)=0.85
Xcell_13_9 row_13_9 row_13_10 col_13_9 col_14_9 gap_13_9 CELL
.ic v(gap_13_9)=0.85
Xcell_13_10 row_13_10 row_13_11 col_13_10 col_14_10 gap_13_10 CELL
.ic v(gap_13_10)=0.85
Xcell_13_11 row_13_11 row_13_12 col_13_11 col_14_11 gap_13_11 CELL
.ic v(gap_13_11)=0.85
Xcell_13_12 row_13_12 row_13_13 col_13_12 col_14_12 gap_13_12 CELL
.ic v(gap_13_12)=0.85
Xcell_13_13 row_13_13 row_13_14 col_13_13 col_14_13 gap_13_13 CELL
.ic v(gap_13_13)=0.85
Xcell_13_14 row_13_14 row_13_15 col_13_14 col_14_14 gap_13_14 CELL
.ic v(gap_13_14)=0.85
Xcell_13_15 row_13_15 row_13_16 col_13_15 col_14_15 gap_13_15 CELL
.ic v(gap_13_15)=0.85
Xcell_14_0 row_14_0 row_14_1 col_14_0 col_15_0 gap_14_0 CELL
.ic v(gap_14_0)=0.85
Xcell_14_1 row_14_1 row_14_2 col_14_1 col_15_1 gap_14_1 CELL
.ic v(gap_14_1)=0.85
Xcell_14_2 row_14_2 row_14_3 col_14_2 col_15_2 gap_14_2 CELL
.ic v(gap_14_2)=0.85
Xcell_14_3 row_14_3 row_14_4 col_14_3 col_15_3 gap_14_3 CELL
.ic v(gap_14_3)=0.85
Xcell_14_4 row_14_4 row_14_5 col_14_4 col_15_4 gap_14_4 CELL
.ic v(gap_14_4)=0.85
Xcell_14_5 row_14_5 row_14_6 col_14_5 col_15_5 gap_14_5 CELL
.ic v(gap_14_5)=0.85
Xcell_14_6 row_14_6 row_14_7 col_14_6 col_15_6 gap_14_6 CELL
.ic v(gap_14_6)=0.85
Xcell_14_7 row_14_7 row_14_8 col_14_7 col_15_7 gap_14_7 CELL
.ic v(gap_14_7)=0.85
Xcell_14_8 row_14_8 row_14_9 col_14_8 col_15_8 gap_14_8 CELL
.ic v(gap_14_8)=0.85
Xcell_14_9 row_14_9 row_14_10 col_14_9 col_15_9 gap_14_9 CELL
.ic v(gap_14_9)=0.85
Xcell_14_10 row_14_10 row_14_11 col_14_10 col_15_10 gap_14_10 CELL
.ic v(gap_14_10)=0.85
Xcell_14_11 row_14_11 row_14_12 col_14_11 col_15_11 gap_14_11 CELL
.ic v(gap_14_11)=0.85
Xcell_14_12 row_14_12 row_14_13 col_14_12 col_15_12 gap_14_12 CELL
.ic v(gap_14_12)=0.85
Xcell_14_13 row_14_13 row_14_14 col_14_13 col_15_13 gap_14_13 CELL
.ic v(gap_14_13)=0.85
Xcell_14_14 row_14_14 row_14_15 col_14_14 col_15_14 gap_14_14 CELL
.ic v(gap_14_14)=0.85
Xcell_14_15 row_14_15 row_14_16 col_14_15 col_15_15 gap_14_15 CELL
.ic v(gap_14_15)=0.85
Xcell_15_0 row_15_0 row_15_1 col_15_0 col_16_0 gap_15_0 CELL
.ic v(gap_15_0)=0.85
Xcell_15_1 row_15_1 row_15_2 col_15_1 col_16_1 gap_15_1 CELL
.ic v(gap_15_1)=0.85
Xcell_15_2 row_15_2 row_15_3 col_15_2 col_16_2 gap_15_2 CELL
.ic v(gap_15_2)=0.85
Xcell_15_3 row_15_3 row_15_4 col_15_3 col_16_3 gap_15_3 CELL
.ic v(gap_15_3)=0.85
Xcell_15_4 row_15_4 row_15_5 col_15_4 col_16_4 gap_15_4 CELL
.ic v(gap_15_4)=0.85
Xcell_15_5 row_15_5 row_15_6 col_15_5 col_16_5 gap_15_5 CELL
.ic v(gap_15_5)=0.85
Xcell_15_6 row_15_6 row_15_7 col_15_6 col_16_6 gap_15_6 CELL
.ic v(gap_15_6)=0.85
Xcell_15_7 row_15_7 row_15_8 col_15_7 col_16_7 gap_15_7 CELL
.ic v(gap_15_7)=0.85
Xcell_15_8 row_15_8 row_15_9 col_15_8 col_16_8 gap_15_8 CELL
.ic v(gap_15_8)=0.85
Xcell_15_9 row_15_9 row_15_10 col_15_9 col_16_9 gap_15_9 CELL
.ic v(gap_15_9)=0.85
Xcell_15_10 row_15_10 row_15_11 col_15_10 col_16_10 gap_15_10 CELL
.ic v(gap_15_10)=0.85
Xcell_15_11 row_15_11 row_15_12 col_15_11 col_16_11 gap_15_11 CELL
.ic v(gap_15_11)=0.85
Xcell_15_12 row_15_12 row_15_13 col_15_12 col_16_12 gap_15_12 CELL
.ic v(gap_15_12)=0.85
Xcell_15_13 row_15_13 row_15_14 col_15_13 col_16_13 gap_15_13 CELL
.ic v(gap_15_13)=0.85
Xcell_15_14 row_15_14 row_15_15 col_15_14 col_16_14 gap_15_14 CELL
.ic v(gap_15_14)=0.85
Xcell_15_15 row_15_15 row_15_16 col_15_15 col_16_15 gap_15_15 CELL
.ic v(gap_15_15)=0.85

** PWL voltage waveforms **
Vrow_0 row_0_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.2            2.9e-06 0.2          3e-06 0              3.9e-06 0            4e-06 0.2            4.9e-06 0.2          5e-06 0              5.9e-06 0            6e-06 0.2            6.9e-06 0.2          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.2            2.09e-05 0.2         2.1e-05 0            2.19e-05 0           2.2e-05 0.2          2.29e-05 0.2         2.3e-05 0            2.39e-05 0           2.4e-05 0.2          2.49e-05 0.2         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 1.5          8.29e-05 1.5         8.3e-05 0            8.39e-05 0           8.4e-05 0            8.49e-05 0           8.5e-05 0            8.59e-05 0           8.6e-05 1.5          8.69e-05 1.5         8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0             0.0001009 0          0.000101 0           0.0001019 0          0.000102 1.5         0.0001029 1.5        0.000103 0           0.0001039 0          0.000104 0           0.0001049 0          0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.2         0.0001629 0.2        0.000163 0           0.0001639 0          0.000164 0.2         0.0001649 0.2        0.000165 0           0.0001659 0          0.000166 0.2         0.0001669 0.2        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.2          0.0001809 0.2        0.000181 0           0.0001819 0          0.000182 0.2         0.0001829 0.2        0.000183 0           0.0001839 0          0.000184 0.2         0.0001849 0.2        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0           0.0002429 0          0.000243 0           0.0002439 0          0.000244 1.5         0.0002449 1.5        0.000245 0           0.0002459 0          0.000246 0           0.0002469 0          0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 1.5          0.0002609 1.5        0.000261 0           0.0002619 0          0.000262 0           0.0002629 0          0.000263 0           0.0002639 0          0.000264 1.5         0.0002649 1.5        0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.2         0.0003229 0.2        0.000323 0           0.0003239 0          0.000324 0.2         0.0003249 0.2        0.000325 0           0.0003259 0          0.000326 0.2         0.0003269 0.2        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.2          0.0003409 0.2        0.000341 0           0.0003419 0          0.000342 0.2         0.0003429 0.2        0.000343 0           0.0003439 0          0.000344 0.2         0.0003449 0.2        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_1 row_1_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.2            8.9e-06 0.2          9e-06 0              9.9e-06 0            1e-05 0.2            1.09e-05 0.2         1.1e-05 0            1.19e-05 0           1.2e-05 0.2          1.29e-05 0.2         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.2          2.69e-05 0.2         2.7e-05 0            2.79e-05 0           2.8e-05 0.2          2.89e-05 0.2         2.9e-05 0            2.99e-05 0           3e-05 0.2            3.09e-05 0.2         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0            8.89e-05 0           8.9e-05 0            8.99e-05 0           9e-05 1.5            9.09e-05 1.5         9.1e-05 0            9.19e-05 0           9.2e-05 0            9.29e-05 0           9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 1.5         0.0001069 1.5        0.000107 0           0.0001079 0          0.000108 0           0.0001089 0          0.000109 0           0.0001099 0          0.00011 1.5          0.0001109 1.5        0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.2         0.0001689 0.2        0.000169 0           0.0001699 0          0.00017 0.2          0.0001709 0.2        0.000171 0           0.0001719 0          0.000172 0.2         0.0001729 0.2        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.2         0.0001869 0.2        0.000187 0           0.0001879 0          0.000188 0.2         0.0001889 0.2        0.000189 0           0.0001899 0          0.00019 0.2          0.0001909 0.2        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 1.5         0.0002489 1.5        0.000249 0           0.0002499 0          0.00025 0            0.0002509 0          0.000251 0           0.0002519 0          0.000252 1.5         0.0002529 1.5        0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0           0.0002669 0          0.000267 0           0.0002679 0          0.000268 1.5         0.0002689 1.5        0.000269 0           0.0002699 0          0.00027 0            0.0002709 0          0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.2         0.0003289 0.2        0.000329 0           0.0003299 0          0.00033 0.2          0.0003309 0.2        0.000331 0           0.0003319 0          0.000332 0.2         0.0003329 0.2        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.2         0.0003469 0.2        0.000347 0           0.0003479 0          0.000348 0.2         0.0003489 0.2        0.000349 0           0.0003499 0          0.00035 0.2          0.0003509 0.2        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_2 row_2_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.2          1.49e-05 0.2         1.5e-05 0            1.59e-05 0           1.6e-05 0.2          1.69e-05 0.2         1.7e-05 0            1.79e-05 0           1.8e-05 0.2          1.89e-05 0.2         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.2          3.29e-05 0.2         3.3e-05 0            3.39e-05 0           3.4e-05 0.2          3.49e-05 0.2         3.5e-05 0            3.59e-05 0           3.6e-05 0.2          3.69e-05 0.2         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 1.5          9.49e-05 1.5         9.5e-05 0            9.59e-05 0           9.6e-05 0            9.69e-05 0           9.7e-05 0            9.79e-05 0           9.8e-05 1.5          9.89e-05 1.5         9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0           0.0001129 0          0.000113 0           0.0001139 0          0.000114 1.5         0.0001149 1.5        0.000115 0           0.0001159 0          0.000116 0           0.0001169 0          0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.2         0.0001749 0.2        0.000175 0           0.0001759 0          0.000176 0.2         0.0001769 0.2        0.000177 0           0.0001779 0          0.000178 0.2         0.0001789 0.2        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.2         0.0001929 0.2        0.000193 0           0.0001939 0          0.000194 0.2         0.0001949 0.2        0.000195 0           0.0001959 0          0.000196 0.2         0.0001969 0.2        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0           0.0002549 0          0.000255 0           0.0002559 0          0.000256 1.5         0.0002569 1.5        0.000257 0           0.0002579 0          0.000258 0           0.0002589 0          0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 1.5         0.0002729 1.5        0.000273 0           0.0002739 0          0.000274 0           0.0002749 0          0.000275 0           0.0002759 0          0.000276 1.5         0.0002769 1.5        0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.2         0.0003349 0.2        0.000335 0           0.0003359 0          0.000336 0.2         0.0003369 0.2        0.000337 0           0.0003379 0          0.000338 0.2         0.0003389 0.2        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.2         0.0003529 0.2        0.000353 0           0.0003539 0          0.000354 0.2         0.0003549 0.2        0.000355 0           0.0003559 0          0.000356 0.2         0.0003569 0.2        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_3 row_3_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_4 row_4_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_5 row_5_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_6 row_6_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_7 row_7_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.2          3.89e-05 0.2         3.9e-05 0            3.99e-05 0           4e-05 0.2            4.09e-05 0.2         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 1.5         0.0001189 1.5        0.000119 0           0.0001199 0          0.00012 0            0.0001209 0          0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.2         0.0001989 0.2        0.000199 0           0.0001999 0          0.0002 0.2           0.0002009 0.2        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0           0.0002789 0          0.000279 0           0.0002799 0          0.00028 1.5          0.0002809 1.5        0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.2         0.0003589 0.2        0.000359 0           0.0003599 0          0.00036 0.2          0.0003609 0.2        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_8 row_8_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.2          4.29e-05 0.2         4.3e-05 0            4.39e-05 0           4.4e-05 0.2          4.49e-05 0.2         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0           0.0001229 0          0.000123 0           0.0001239 0          0.000124 1.5         0.0001249 1.5        0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.2         0.0002029 0.2        0.000203 0           0.0002039 0          0.000204 0.2         0.0002049 0.2        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 1.5         0.0002829 1.5        0.000283 0           0.0002839 0          0.000284 0           0.0002849 0          0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.2         0.0003629 0.2        0.000363 0           0.0003639 0          0.000364 0.2         0.0003649 0.2        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_9 row_9_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_10 row_10_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_11 row_11_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_12 row_12_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_13 row_13_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.2          4.69e-05 0.2         4.7e-05 0            4.79e-05 0           4.8e-05 0.2          4.89e-05 0.2         4.9e-05 0            4.99e-05 0           5e-05 0.2            5.09e-05 0.2         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.2          6.49e-05 0.2         6.5e-05 0            6.59e-05 0           6.6e-05 0.2          6.69e-05 0.2         6.7e-05 0            6.79e-05 0           6.8e-05 0.2          6.89e-05 0.2         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0           0.0001269 0          0.000127 0           0.0001279 0          0.000128 1.5         0.0001289 1.5        0.000129 0           0.0001299 0          0.00013 0            0.0001309 0          0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 1.5         0.0001449 1.5        0.000145 0           0.0001459 0          0.000146 0           0.0001469 0          0.000147 0           0.0001479 0          0.000148 1.5         0.0001489 1.5        0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.2         0.0002069 0.2        0.000207 0           0.0002079 0          0.000208 0.2         0.0002089 0.2        0.000209 0           0.0002099 0          0.00021 0.2          0.0002109 0.2        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.2         0.0002249 0.2        0.000225 0           0.0002259 0          0.000226 0.2         0.0002269 0.2        0.000227 0           0.0002279 0          0.000228 0.2         0.0002289 0.2        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 1.5         0.0002869 1.5        0.000287 0           0.0002879 0          0.000288 0           0.0002889 0          0.000289 0           0.0002899 0          0.00029 1.5          0.0002909 1.5        0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0           0.0003049 0          0.000305 0           0.0003059 0          0.000306 1.5         0.0003069 1.5        0.000307 0           0.0003079 0          0.000308 0           0.0003089 0          0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.2         0.0003669 0.2        0.000367 0           0.0003679 0          0.000368 0.2         0.0003689 0.2        0.000369 0           0.0003699 0          0.00037 0.2          0.0003709 0.2        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.2         0.0003849 0.2        0.000385 0           0.0003859 0          0.000386 0.2         0.0003869 0.2        0.000387 0           0.0003879 0          0.000388 0.2         0.0003889 0.2        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_14 row_14_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.2          5.29e-05 0.2         5.3e-05 0            5.39e-05 0           5.4e-05 0.2          5.49e-05 0.2         5.5e-05 0            5.59e-05 0           5.6e-05 0.2          5.69e-05 0.2         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.2            7.09e-05 0.2         7.1e-05 0            7.19e-05 0           7.2e-05 0.2          7.29e-05 0.2         7.3e-05 0            7.39e-05 0           7.4e-05 0.2          7.49e-05 0.2         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 1.5         0.0001329 1.5        0.000133 0           0.0001339 0          0.000134 0           0.0001349 0          0.000135 0           0.0001359 0          0.000136 1.5         0.0001369 1.5        0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0            0.0001509 0          0.000151 0           0.0001519 0          0.000152 1.5         0.0001529 1.5        0.000153 0           0.0001539 0          0.000154 0           0.0001549 0          0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.2         0.0002129 0.2        0.000213 0           0.0002139 0          0.000214 0.2         0.0002149 0.2        0.000215 0           0.0002159 0          0.000216 0.2         0.0002169 0.2        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.2          0.0002309 0.2        0.000231 0           0.0002319 0          0.000232 0.2         0.0002329 0.2        0.000233 0           0.0002339 0          0.000234 0.2         0.0002349 0.2        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0           0.0002929 0          0.000293 0           0.0002939 0          0.000294 1.5         0.0002949 1.5        0.000295 0           0.0002959 0          0.000296 0           0.0002969 0          0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 1.5          0.0003109 1.5        0.000311 0           0.0003119 0          0.000312 0           0.0003129 0          0.000313 0           0.0003139 0          0.000314 1.5         0.0003149 1.5        0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.2         0.0003729 0.2        0.000373 0           0.0003739 0          0.000374 0.2         0.0003749 0.2        0.000375 0           0.0003759 0          0.000376 0.2         0.0003769 0.2        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.2          0.0003909 0.2        0.000391 0           0.0003919 0          0.000392 0.2         0.0003929 0.2        0.000393 0           0.0003939 0          0.000394 0.2         0.0003949 0.2        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_15 row_15_0 0 PWLZ(0 0                  9e-07 0              1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.2          5.89e-05 0.2         5.9e-05 0            5.99e-05 0           6e-05 0.2            6.09e-05 0.2         6.1e-05 0            6.19e-05 0           6.2e-05 0.2          6.29e-05 0.2         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.2          7.69e-05 0.2         7.7e-05 0            7.79e-05 0           7.8e-05 0.2          7.89e-05 0.2         7.9e-05 0            7.99e-05 0           8e-05 0.2            8.09e-05 0.2         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0           0.0001389 0          0.000139 0           0.0001399 0          0.00014 1.5          0.0001409 1.5        0.000141 0           0.0001419 0          0.000142 0           0.0001429 0          0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 1.5         0.0001569 1.5        0.000157 0           0.0001579 0          0.000158 0           0.0001589 0          0.000159 0           0.0001599 0          0.00016 1.5          0.0001609 1.5        0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.2         0.0002189 0.2        0.000219 0           0.0002199 0          0.00022 0.2          0.0002209 0.2        0.000221 0           0.0002219 0          0.000222 0.2         0.0002229 0.2        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.2         0.0002369 0.2        0.000237 0           0.0002379 0          0.000238 0.2         0.0002389 0.2        0.000239 0           0.0002399 0          0.00024 0.2          0.0002409 0.2        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 1.5         0.0002989 1.5        0.000299 0           0.0002999 0          0.0003 0             0.0003009 0          0.000301 0           0.0003019 0          0.000302 1.5         0.0003029 1.5        0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0           0.0003169 0          0.000317 0           0.0003179 0          0.000318 1.5         0.0003189 1.5        0.000319 0           0.0003199 0          0.00032 0            0.0003209 0          0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.2         0.0003789 0.2        0.000379 0           0.0003799 0          0.00038 0.2          0.0003809 0.2        0.000381 0           0.0003819 0          0.000382 0.2         0.0003829 0.2        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.2         0.0003969 0.2        0.000397 0           0.0003979 0          0.000398 0.2         0.0003989 0.2        0.000399 0           0.0003999 0          0.0004 0.2           0.0004009 0.2        0.000401 0           0.0004019 0         )
Vcol_0 col_0_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0              2.9e-06 0            3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0              8.9e-06 0            9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0            1.49e-05 0           1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0            4.69e-05 0           4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0            5.29e-05 0           5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0            5.89e-05 0           5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0            8.29e-05 0           8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 1.5          8.89e-05 1.5         8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0            9.49e-05 0           9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 1.5         0.0001269 1.5        0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0           0.0001329 0          0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 1.5         0.0001389 1.5        0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0           0.0001629 0          0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0           0.0001689 0          0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0           0.0001749 0          0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0           0.0002069 0          0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0           0.0002129 0          0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0           0.0002189 0          0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 1.5         0.0002429 1.5        0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0           0.0002489 0          0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 1.5         0.0002549 1.5        0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0           0.0002869 0          0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 1.5         0.0002929 1.5        0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0           0.0002989 0          0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0           0.0003229 0          0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0           0.0003289 0          0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0           0.0003349 0          0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0           0.0003669 0          0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0           0.0003729 0          0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0           0.0003789 0          0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_1 col_0_1 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0              4.9e-06 0            5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0              1.09e-05 0           1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0            1.69e-05 0           1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0            4.89e-05 0           4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0            5.49e-05 0           5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0              6.09e-05 0           6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 1.5          8.49e-05 1.5         8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0              9.09e-05 0           9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 1.5          9.69e-05 1.5         9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0           0.0001289 0          0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 1.5         0.0001349 1.5        0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0            0.0001409 0          0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0           0.0001649 0          0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0            0.0001709 0          0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0           0.0001769 0          0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0           0.0002089 0          0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0           0.0002149 0          0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0            0.0002209 0          0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0           0.0002449 0          0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 1.5          0.0002509 1.5        0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0           0.0002569 0          0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 1.5         0.0002889 1.5        0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0           0.0002949 0          0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 1.5           0.0003009 1.5        0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0           0.0003249 0          0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0            0.0003309 0          0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0           0.0003369 0          0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0           0.0003689 0          0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0           0.0003749 0          0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0            0.0003809 0          0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_2 col_0_2 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0              6.9e-06 0            7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0            1.29e-05 0           1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0            1.89e-05 0           1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0              5.09e-05 0           5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0            5.69e-05 0           5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0            6.29e-05 0           6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0            8.69e-05 0           8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 1.5          9.29e-05 1.5         9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0            9.89e-05 0           9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 1.5          0.0001309 1.5        0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0           0.0001369 0          0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 1.5         0.0001429 1.5        0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0           0.0001669 0          0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0           0.0001729 0          0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0           0.0001789 0          0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0            0.0002109 0          0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0           0.0002169 0          0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0           0.0002229 0          0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 1.5         0.0002469 1.5        0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0           0.0002529 0          0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 1.5         0.0002589 1.5        0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0            0.0002909 0          0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 1.5         0.0002969 1.5        0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0           0.0003029 0          0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0           0.0003269 0          0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0           0.0003329 0          0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0           0.0003389 0          0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0            0.0003709 0          0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0           0.0003769 0          0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0           0.0003829 0          0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_3 col_0_3 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_4 col_0_4 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_5 col_0_5 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_6 col_0_6 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_7 col_0_7 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0            3.89e-05 0           3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0            4.29e-05 0           4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0           0.0001189 0          0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 1.5         0.0001229 1.5        0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0           0.0001989 0          0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0           0.0002029 0          0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 1.5         0.0002789 1.5        0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0           0.0002829 0          0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0           0.0003589 0          0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0           0.0003629 0          0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_8 col_0_8 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0              4.09e-05 0           4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0            4.49e-05 0           4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 1.5          0.0001209 1.5        0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0           0.0001249 0          0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0             0.0002009 0          0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0           0.0002049 0          0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0            0.0002809 0          0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 1.5         0.0002849 1.5        0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0            0.0003609 0          0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0           0.0003649 0          0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_9 col_0_9 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_10 col_0_10 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_11 col_0_11 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_12 col_0_12 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_13 col_0_13 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0              2.09e-05 0           2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0            2.69e-05 0           2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0            3.29e-05 0           3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0            6.49e-05 0           6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0              7.09e-05 0           7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0            7.69e-05 0           7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 1.5           0.0001009 1.5        0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0           0.0001069 0          0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 1.5         0.0001129 1.5        0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0           0.0001449 0          0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 1.5          0.0001509 1.5        0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0           0.0001569 0          0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0            0.0001809 0          0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0           0.0001869 0          0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0           0.0001929 0          0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0           0.0002249 0          0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0            0.0002309 0          0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0           0.0002369 0          0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0            0.0002609 0          0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 1.5         0.0002669 1.5        0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0           0.0002729 0          0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 1.5         0.0003049 1.5        0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0            0.0003109 0          0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 1.5         0.0003169 1.5        0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0            0.0003409 0          0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0           0.0003469 0          0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0           0.0003529 0          0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0           0.0003849 0          0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0            0.0003909 0          0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0           0.0003969 0          0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_14 col_0_14 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0            2.29e-05 0           2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0            2.89e-05 0           2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0            3.49e-05 0           3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0            6.69e-05 0           6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0            7.29e-05 0           7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0            7.89e-05 0           7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0           0.0001029 0          0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 1.5         0.0001089 1.5        0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0           0.0001149 0          0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 1.5         0.0001469 1.5        0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0           0.0001529 0          0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 1.5         0.0001589 1.5        0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0           0.0001829 0          0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0           0.0001889 0          0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0           0.0001949 0          0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0           0.0002269 0          0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0           0.0002329 0          0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0           0.0002389 0          0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 1.5         0.0002629 1.5        0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0           0.0002689 0          0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 1.5         0.0002749 1.5        0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0           0.0003069 0          0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 1.5         0.0003129 1.5        0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0           0.0003189 0          0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0           0.0003429 0          0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0           0.0003489 0          0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0           0.0003549 0          0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0           0.0003869 0          0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0           0.0003929 0          0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0           0.0003989 0          0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_15 col_0_15 0 PWLZ(0 0                  9e-07 0              1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0            2.49e-05 0           2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0              3.09e-05 0           3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0            3.69e-05 0           3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0            6.89e-05 0           6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0            7.49e-05 0           7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0              8.09e-05 0           8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 1.5         0.0001049 1.5        0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0            0.0001109 0          0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 1.5         0.0001169 1.5        0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0           0.0001489 0          0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 1.5         0.0001549 1.5        0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0            0.0001609 0          0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0           0.0001849 0          0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0            0.0001909 0          0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0           0.0001969 0          0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0           0.0002289 0          0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0           0.0002349 0          0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0            0.0002409 0          0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0           0.0002649 0          0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 1.5          0.0002709 1.5        0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0           0.0002769 0          0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 1.5         0.0003089 1.5        0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0           0.0003149 0          0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 1.5          0.0003209 1.5        0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0           0.0003449 0          0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0            0.0003509 0          0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0           0.0003569 0          0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0           0.0003889 0          0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0           0.0003949 0          0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0             0.0004009 0          0.000401 0           0.0004019 0         )

** Transient analysis **
.tran 1e-07 0.000402

.end

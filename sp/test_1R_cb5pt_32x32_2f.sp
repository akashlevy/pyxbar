.title <test_1R_cb5pt_32x32_2f>

** Includes **

** Load models **
.hdl ../models/rram_wp.va

** Options **
.option post=2
.option probe

** Parameters **

** Probes **
.probe V(gap_0_0)
.probe V(gap_0_1)
.probe V(gap_0_2)
.probe V(gap_1_0)
.probe V(gap_1_1)
.probe V(gap_1_2)
.probe V(gap_2_0)
.probe V(gap_2_1)
.probe V(gap_2_2)
.probe V(gap_0_29)
.probe V(gap_0_30)
.probe V(gap_0_31)
.probe V(gap_1_29)
.probe V(gap_1_30)
.probe V(gap_1_31)
.probe V(gap_2_29)
.probe V(gap_2_30)
.probe V(gap_2_31)
.probe V(gap_15_15)
.probe V(gap_15_16)
.probe V(gap_16_15)
.probe V(gap_16_16)
.probe V(gap_29_0)
.probe V(gap_29_1)
.probe V(gap_29_2)
.probe V(gap_30_0)
.probe V(gap_30_1)
.probe V(gap_30_2)
.probe V(gap_31_0)
.probe V(gap_31_1)
.probe V(gap_31_2)
.probe V(gap_29_29)
.probe V(gap_29_30)
.probe V(gap_29_31)
.probe V(gap_30_29)
.probe V(gap_30_30)
.probe V(gap_30_31)
.probe V(gap_31_29)
.probe V(gap_31_30)
.probe V(gap_31_31)
.probe V(row_0_0)
.probe V(row_1_0)
.probe V(row_2_0)
.probe V(row_3_0)
.probe V(row_4_0)
.probe V(row_5_0)
.probe V(row_6_0)
.probe V(row_7_0)
.probe V(row_8_0)
.probe V(row_9_0)
.probe V(row_10_0)
.probe V(row_11_0)
.probe V(row_12_0)
.probe V(row_13_0)
.probe V(row_14_0)
.probe V(row_15_0)
.probe V(row_16_0)
.probe V(row_17_0)
.probe V(row_18_0)
.probe V(row_19_0)
.probe V(row_20_0)
.probe V(row_21_0)
.probe V(row_22_0)
.probe V(row_23_0)
.probe V(row_24_0)
.probe V(row_25_0)
.probe V(row_26_0)
.probe V(row_27_0)
.probe V(row_28_0)
.probe V(row_29_0)
.probe V(row_30_0)
.probe V(row_31_0)
.probe V(col_0_0)
.probe V(col_0_1)
.probe V(col_0_2)
.probe V(col_0_3)
.probe V(col_0_4)
.probe V(col_0_5)
.probe V(col_0_6)
.probe V(col_0_7)
.probe V(col_0_8)
.probe V(col_0_9)
.probe V(col_0_10)
.probe V(col_0_11)
.probe V(col_0_12)
.probe V(col_0_13)
.probe V(col_0_14)
.probe V(col_0_15)
.probe V(col_0_16)
.probe V(col_0_17)
.probe V(col_0_18)
.probe V(col_0_19)
.probe V(col_0_20)
.probe V(col_0_21)
.probe V(col_0_22)
.probe V(col_0_23)
.probe V(col_0_24)
.probe V(col_0_25)
.probe V(col_0_26)
.probe V(col_0_27)
.probe V(col_0_28)
.probe V(col_0_29)
.probe V(col_0_30)
.probe V(col_0_31)
.probe I(Vrow_0)
.probe I(Vrow_1)
.probe I(Vrow_2)
.probe I(Vrow_3)
.probe I(Vrow_4)
.probe I(Vrow_5)
.probe I(Vrow_6)
.probe I(Vrow_7)
.probe I(Vrow_8)
.probe I(Vrow_9)
.probe I(Vrow_10)
.probe I(Vrow_11)
.probe I(Vrow_12)
.probe I(Vrow_13)
.probe I(Vrow_14)
.probe I(Vrow_15)
.probe I(Vrow_16)
.probe I(Vrow_17)
.probe I(Vrow_18)
.probe I(Vrow_19)
.probe I(Vrow_20)
.probe I(Vrow_21)
.probe I(Vrow_22)
.probe I(Vrow_23)
.probe I(Vrow_24)
.probe I(Vrow_25)
.probe I(Vrow_26)
.probe I(Vrow_27)
.probe I(Vrow_28)
.probe I(Vrow_29)
.probe I(Vrow_30)
.probe I(Vrow_31)
.probe I(Vcol_0)
.probe I(Vcol_1)
.probe I(Vcol_2)
.probe I(Vcol_3)
.probe I(Vcol_4)
.probe I(Vcol_5)
.probe I(Vcol_6)
.probe I(Vcol_7)
.probe I(Vcol_8)
.probe I(Vcol_9)
.probe I(Vcol_10)
.probe I(Vcol_11)
.probe I(Vcol_12)
.probe I(Vcol_13)
.probe I(Vcol_14)
.probe I(Vcol_15)
.probe I(Vcol_16)
.probe I(Vcol_17)
.probe I(Vcol_18)
.probe I(Vcol_19)
.probe I(Vcol_20)
.probe I(Vcol_21)
.probe I(Vcol_22)
.probe I(Vcol_23)
.probe I(Vcol_24)
.probe I(Vcol_25)
.probe I(Vcol_26)
.probe I(Vcol_27)
.probe I(Vcol_28)
.probe I(Vcol_29)
.probe I(Vcol_30)
.probe I(Vcol_31)

** Sub-circuits **
.subckt CELL r1 r2 c1 c2 gap
Rr r1 r2 0.18
Cr r2 gnd 1.08e-13
Rc c1 c2 0.18
Cc c2 gnd 1.08e-13
X1 r1 c1 gap RRAM_v0
.ends CELL

** Crossbar instantiation **
Xcell_0_0 row_0_0 row_0_1 col_0_0 col_1_0 gap_0_0 CELL
Xcell_0_1 row_0_1 row_0_2 col_0_1 col_1_1 gap_0_1 CELL
Xcell_0_2 row_0_2 row_0_3 col_0_2 col_1_2 gap_0_2 CELL
Xcell_0_3 row_0_3 row_0_4 col_0_3 col_1_3 gap_0_3 CELL
Xcell_0_4 row_0_4 row_0_5 col_0_4 col_1_4 gap_0_4 CELL
Xcell_0_5 row_0_5 row_0_6 col_0_5 col_1_5 gap_0_5 CELL
Xcell_0_6 row_0_6 row_0_7 col_0_6 col_1_6 gap_0_6 CELL
Xcell_0_7 row_0_7 row_0_8 col_0_7 col_1_7 gap_0_7 CELL
Xcell_0_8 row_0_8 row_0_9 col_0_8 col_1_8 gap_0_8 CELL
Xcell_0_9 row_0_9 row_0_10 col_0_9 col_1_9 gap_0_9 CELL
Xcell_0_10 row_0_10 row_0_11 col_0_10 col_1_10 gap_0_10 CELL
Xcell_0_11 row_0_11 row_0_12 col_0_11 col_1_11 gap_0_11 CELL
Xcell_0_12 row_0_12 row_0_13 col_0_12 col_1_12 gap_0_12 CELL
Xcell_0_13 row_0_13 row_0_14 col_0_13 col_1_13 gap_0_13 CELL
Xcell_0_14 row_0_14 row_0_15 col_0_14 col_1_14 gap_0_14 CELL
Xcell_0_15 row_0_15 row_0_16 col_0_15 col_1_15 gap_0_15 CELL
Xcell_0_16 row_0_16 row_0_17 col_0_16 col_1_16 gap_0_16 CELL
Xcell_0_17 row_0_17 row_0_18 col_0_17 col_1_17 gap_0_17 CELL
Xcell_0_18 row_0_18 row_0_19 col_0_18 col_1_18 gap_0_18 CELL
Xcell_0_19 row_0_19 row_0_20 col_0_19 col_1_19 gap_0_19 CELL
Xcell_0_20 row_0_20 row_0_21 col_0_20 col_1_20 gap_0_20 CELL
Xcell_0_21 row_0_21 row_0_22 col_0_21 col_1_21 gap_0_21 CELL
Xcell_0_22 row_0_22 row_0_23 col_0_22 col_1_22 gap_0_22 CELL
Xcell_0_23 row_0_23 row_0_24 col_0_23 col_1_23 gap_0_23 CELL
Xcell_0_24 row_0_24 row_0_25 col_0_24 col_1_24 gap_0_24 CELL
Xcell_0_25 row_0_25 row_0_26 col_0_25 col_1_25 gap_0_25 CELL
Xcell_0_26 row_0_26 row_0_27 col_0_26 col_1_26 gap_0_26 CELL
Xcell_0_27 row_0_27 row_0_28 col_0_27 col_1_27 gap_0_27 CELL
Xcell_0_28 row_0_28 row_0_29 col_0_28 col_1_28 gap_0_28 CELL
Xcell_0_29 row_0_29 row_0_30 col_0_29 col_1_29 gap_0_29 CELL
Xcell_0_30 row_0_30 row_0_31 col_0_30 col_1_30 gap_0_30 CELL
Xcell_0_31 row_0_31 row_0_32 col_0_31 col_1_31 gap_0_31 CELL
Xcell_1_0 row_1_0 row_1_1 col_1_0 col_2_0 gap_1_0 CELL
Xcell_1_1 row_1_1 row_1_2 col_1_1 col_2_1 gap_1_1 CELL
Xcell_1_2 row_1_2 row_1_3 col_1_2 col_2_2 gap_1_2 CELL
Xcell_1_3 row_1_3 row_1_4 col_1_3 col_2_3 gap_1_3 CELL
Xcell_1_4 row_1_4 row_1_5 col_1_4 col_2_4 gap_1_4 CELL
Xcell_1_5 row_1_5 row_1_6 col_1_5 col_2_5 gap_1_5 CELL
Xcell_1_6 row_1_6 row_1_7 col_1_6 col_2_6 gap_1_6 CELL
Xcell_1_7 row_1_7 row_1_8 col_1_7 col_2_7 gap_1_7 CELL
Xcell_1_8 row_1_8 row_1_9 col_1_8 col_2_8 gap_1_8 CELL
Xcell_1_9 row_1_9 row_1_10 col_1_9 col_2_9 gap_1_9 CELL
Xcell_1_10 row_1_10 row_1_11 col_1_10 col_2_10 gap_1_10 CELL
Xcell_1_11 row_1_11 row_1_12 col_1_11 col_2_11 gap_1_11 CELL
Xcell_1_12 row_1_12 row_1_13 col_1_12 col_2_12 gap_1_12 CELL
Xcell_1_13 row_1_13 row_1_14 col_1_13 col_2_13 gap_1_13 CELL
Xcell_1_14 row_1_14 row_1_15 col_1_14 col_2_14 gap_1_14 CELL
Xcell_1_15 row_1_15 row_1_16 col_1_15 col_2_15 gap_1_15 CELL
Xcell_1_16 row_1_16 row_1_17 col_1_16 col_2_16 gap_1_16 CELL
Xcell_1_17 row_1_17 row_1_18 col_1_17 col_2_17 gap_1_17 CELL
Xcell_1_18 row_1_18 row_1_19 col_1_18 col_2_18 gap_1_18 CELL
Xcell_1_19 row_1_19 row_1_20 col_1_19 col_2_19 gap_1_19 CELL
Xcell_1_20 row_1_20 row_1_21 col_1_20 col_2_20 gap_1_20 CELL
Xcell_1_21 row_1_21 row_1_22 col_1_21 col_2_21 gap_1_21 CELL
Xcell_1_22 row_1_22 row_1_23 col_1_22 col_2_22 gap_1_22 CELL
Xcell_1_23 row_1_23 row_1_24 col_1_23 col_2_23 gap_1_23 CELL
Xcell_1_24 row_1_24 row_1_25 col_1_24 col_2_24 gap_1_24 CELL
Xcell_1_25 row_1_25 row_1_26 col_1_25 col_2_25 gap_1_25 CELL
Xcell_1_26 row_1_26 row_1_27 col_1_26 col_2_26 gap_1_26 CELL
Xcell_1_27 row_1_27 row_1_28 col_1_27 col_2_27 gap_1_27 CELL
Xcell_1_28 row_1_28 row_1_29 col_1_28 col_2_28 gap_1_28 CELL
Xcell_1_29 row_1_29 row_1_30 col_1_29 col_2_29 gap_1_29 CELL
Xcell_1_30 row_1_30 row_1_31 col_1_30 col_2_30 gap_1_30 CELL
Xcell_1_31 row_1_31 row_1_32 col_1_31 col_2_31 gap_1_31 CELL
Xcell_2_0 row_2_0 row_2_1 col_2_0 col_3_0 gap_2_0 CELL
Xcell_2_1 row_2_1 row_2_2 col_2_1 col_3_1 gap_2_1 CELL
Xcell_2_2 row_2_2 row_2_3 col_2_2 col_3_2 gap_2_2 CELL
Xcell_2_3 row_2_3 row_2_4 col_2_3 col_3_3 gap_2_3 CELL
Xcell_2_4 row_2_4 row_2_5 col_2_4 col_3_4 gap_2_4 CELL
Xcell_2_5 row_2_5 row_2_6 col_2_5 col_3_5 gap_2_5 CELL
Xcell_2_6 row_2_6 row_2_7 col_2_6 col_3_6 gap_2_6 CELL
Xcell_2_7 row_2_7 row_2_8 col_2_7 col_3_7 gap_2_7 CELL
Xcell_2_8 row_2_8 row_2_9 col_2_8 col_3_8 gap_2_8 CELL
Xcell_2_9 row_2_9 row_2_10 col_2_9 col_3_9 gap_2_9 CELL
Xcell_2_10 row_2_10 row_2_11 col_2_10 col_3_10 gap_2_10 CELL
Xcell_2_11 row_2_11 row_2_12 col_2_11 col_3_11 gap_2_11 CELL
Xcell_2_12 row_2_12 row_2_13 col_2_12 col_3_12 gap_2_12 CELL
Xcell_2_13 row_2_13 row_2_14 col_2_13 col_3_13 gap_2_13 CELL
Xcell_2_14 row_2_14 row_2_15 col_2_14 col_3_14 gap_2_14 CELL
Xcell_2_15 row_2_15 row_2_16 col_2_15 col_3_15 gap_2_15 CELL
Xcell_2_16 row_2_16 row_2_17 col_2_16 col_3_16 gap_2_16 CELL
Xcell_2_17 row_2_17 row_2_18 col_2_17 col_3_17 gap_2_17 CELL
Xcell_2_18 row_2_18 row_2_19 col_2_18 col_3_18 gap_2_18 CELL
Xcell_2_19 row_2_19 row_2_20 col_2_19 col_3_19 gap_2_19 CELL
Xcell_2_20 row_2_20 row_2_21 col_2_20 col_3_20 gap_2_20 CELL
Xcell_2_21 row_2_21 row_2_22 col_2_21 col_3_21 gap_2_21 CELL
Xcell_2_22 row_2_22 row_2_23 col_2_22 col_3_22 gap_2_22 CELL
Xcell_2_23 row_2_23 row_2_24 col_2_23 col_3_23 gap_2_23 CELL
Xcell_2_24 row_2_24 row_2_25 col_2_24 col_3_24 gap_2_24 CELL
Xcell_2_25 row_2_25 row_2_26 col_2_25 col_3_25 gap_2_25 CELL
Xcell_2_26 row_2_26 row_2_27 col_2_26 col_3_26 gap_2_26 CELL
Xcell_2_27 row_2_27 row_2_28 col_2_27 col_3_27 gap_2_27 CELL
Xcell_2_28 row_2_28 row_2_29 col_2_28 col_3_28 gap_2_28 CELL
Xcell_2_29 row_2_29 row_2_30 col_2_29 col_3_29 gap_2_29 CELL
Xcell_2_30 row_2_30 row_2_31 col_2_30 col_3_30 gap_2_30 CELL
Xcell_2_31 row_2_31 row_2_32 col_2_31 col_3_31 gap_2_31 CELL
Xcell_3_0 row_3_0 row_3_1 col_3_0 col_4_0 gap_3_0 CELL
Xcell_3_1 row_3_1 row_3_2 col_3_1 col_4_1 gap_3_1 CELL
Xcell_3_2 row_3_2 row_3_3 col_3_2 col_4_2 gap_3_2 CELL
Xcell_3_3 row_3_3 row_3_4 col_3_3 col_4_3 gap_3_3 CELL
Xcell_3_4 row_3_4 row_3_5 col_3_4 col_4_4 gap_3_4 CELL
Xcell_3_5 row_3_5 row_3_6 col_3_5 col_4_5 gap_3_5 CELL
Xcell_3_6 row_3_6 row_3_7 col_3_6 col_4_6 gap_3_6 CELL
Xcell_3_7 row_3_7 row_3_8 col_3_7 col_4_7 gap_3_7 CELL
Xcell_3_8 row_3_8 row_3_9 col_3_8 col_4_8 gap_3_8 CELL
Xcell_3_9 row_3_9 row_3_10 col_3_9 col_4_9 gap_3_9 CELL
Xcell_3_10 row_3_10 row_3_11 col_3_10 col_4_10 gap_3_10 CELL
Xcell_3_11 row_3_11 row_3_12 col_3_11 col_4_11 gap_3_11 CELL
Xcell_3_12 row_3_12 row_3_13 col_3_12 col_4_12 gap_3_12 CELL
Xcell_3_13 row_3_13 row_3_14 col_3_13 col_4_13 gap_3_13 CELL
Xcell_3_14 row_3_14 row_3_15 col_3_14 col_4_14 gap_3_14 CELL
Xcell_3_15 row_3_15 row_3_16 col_3_15 col_4_15 gap_3_15 CELL
Xcell_3_16 row_3_16 row_3_17 col_3_16 col_4_16 gap_3_16 CELL
Xcell_3_17 row_3_17 row_3_18 col_3_17 col_4_17 gap_3_17 CELL
Xcell_3_18 row_3_18 row_3_19 col_3_18 col_4_18 gap_3_18 CELL
Xcell_3_19 row_3_19 row_3_20 col_3_19 col_4_19 gap_3_19 CELL
Xcell_3_20 row_3_20 row_3_21 col_3_20 col_4_20 gap_3_20 CELL
Xcell_3_21 row_3_21 row_3_22 col_3_21 col_4_21 gap_3_21 CELL
Xcell_3_22 row_3_22 row_3_23 col_3_22 col_4_22 gap_3_22 CELL
Xcell_3_23 row_3_23 row_3_24 col_3_23 col_4_23 gap_3_23 CELL
Xcell_3_24 row_3_24 row_3_25 col_3_24 col_4_24 gap_3_24 CELL
Xcell_3_25 row_3_25 row_3_26 col_3_25 col_4_25 gap_3_25 CELL
Xcell_3_26 row_3_26 row_3_27 col_3_26 col_4_26 gap_3_26 CELL
Xcell_3_27 row_3_27 row_3_28 col_3_27 col_4_27 gap_3_27 CELL
Xcell_3_28 row_3_28 row_3_29 col_3_28 col_4_28 gap_3_28 CELL
Xcell_3_29 row_3_29 row_3_30 col_3_29 col_4_29 gap_3_29 CELL
Xcell_3_30 row_3_30 row_3_31 col_3_30 col_4_30 gap_3_30 CELL
Xcell_3_31 row_3_31 row_3_32 col_3_31 col_4_31 gap_3_31 CELL
Xcell_4_0 row_4_0 row_4_1 col_4_0 col_5_0 gap_4_0 CELL
Xcell_4_1 row_4_1 row_4_2 col_4_1 col_5_1 gap_4_1 CELL
Xcell_4_2 row_4_2 row_4_3 col_4_2 col_5_2 gap_4_2 CELL
Xcell_4_3 row_4_3 row_4_4 col_4_3 col_5_3 gap_4_3 CELL
Xcell_4_4 row_4_4 row_4_5 col_4_4 col_5_4 gap_4_4 CELL
Xcell_4_5 row_4_5 row_4_6 col_4_5 col_5_5 gap_4_5 CELL
Xcell_4_6 row_4_6 row_4_7 col_4_6 col_5_6 gap_4_6 CELL
Xcell_4_7 row_4_7 row_4_8 col_4_7 col_5_7 gap_4_7 CELL
Xcell_4_8 row_4_8 row_4_9 col_4_8 col_5_8 gap_4_8 CELL
Xcell_4_9 row_4_9 row_4_10 col_4_9 col_5_9 gap_4_9 CELL
Xcell_4_10 row_4_10 row_4_11 col_4_10 col_5_10 gap_4_10 CELL
Xcell_4_11 row_4_11 row_4_12 col_4_11 col_5_11 gap_4_11 CELL
Xcell_4_12 row_4_12 row_4_13 col_4_12 col_5_12 gap_4_12 CELL
Xcell_4_13 row_4_13 row_4_14 col_4_13 col_5_13 gap_4_13 CELL
Xcell_4_14 row_4_14 row_4_15 col_4_14 col_5_14 gap_4_14 CELL
Xcell_4_15 row_4_15 row_4_16 col_4_15 col_5_15 gap_4_15 CELL
Xcell_4_16 row_4_16 row_4_17 col_4_16 col_5_16 gap_4_16 CELL
Xcell_4_17 row_4_17 row_4_18 col_4_17 col_5_17 gap_4_17 CELL
Xcell_4_18 row_4_18 row_4_19 col_4_18 col_5_18 gap_4_18 CELL
Xcell_4_19 row_4_19 row_4_20 col_4_19 col_5_19 gap_4_19 CELL
Xcell_4_20 row_4_20 row_4_21 col_4_20 col_5_20 gap_4_20 CELL
Xcell_4_21 row_4_21 row_4_22 col_4_21 col_5_21 gap_4_21 CELL
Xcell_4_22 row_4_22 row_4_23 col_4_22 col_5_22 gap_4_22 CELL
Xcell_4_23 row_4_23 row_4_24 col_4_23 col_5_23 gap_4_23 CELL
Xcell_4_24 row_4_24 row_4_25 col_4_24 col_5_24 gap_4_24 CELL
Xcell_4_25 row_4_25 row_4_26 col_4_25 col_5_25 gap_4_25 CELL
Xcell_4_26 row_4_26 row_4_27 col_4_26 col_5_26 gap_4_26 CELL
Xcell_4_27 row_4_27 row_4_28 col_4_27 col_5_27 gap_4_27 CELL
Xcell_4_28 row_4_28 row_4_29 col_4_28 col_5_28 gap_4_28 CELL
Xcell_4_29 row_4_29 row_4_30 col_4_29 col_5_29 gap_4_29 CELL
Xcell_4_30 row_4_30 row_4_31 col_4_30 col_5_30 gap_4_30 CELL
Xcell_4_31 row_4_31 row_4_32 col_4_31 col_5_31 gap_4_31 CELL
Xcell_5_0 row_5_0 row_5_1 col_5_0 col_6_0 gap_5_0 CELL
Xcell_5_1 row_5_1 row_5_2 col_5_1 col_6_1 gap_5_1 CELL
Xcell_5_2 row_5_2 row_5_3 col_5_2 col_6_2 gap_5_2 CELL
Xcell_5_3 row_5_3 row_5_4 col_5_3 col_6_3 gap_5_3 CELL
Xcell_5_4 row_5_4 row_5_5 col_5_4 col_6_4 gap_5_4 CELL
Xcell_5_5 row_5_5 row_5_6 col_5_5 col_6_5 gap_5_5 CELL
Xcell_5_6 row_5_6 row_5_7 col_5_6 col_6_6 gap_5_6 CELL
Xcell_5_7 row_5_7 row_5_8 col_5_7 col_6_7 gap_5_7 CELL
Xcell_5_8 row_5_8 row_5_9 col_5_8 col_6_8 gap_5_8 CELL
Xcell_5_9 row_5_9 row_5_10 col_5_9 col_6_9 gap_5_9 CELL
Xcell_5_10 row_5_10 row_5_11 col_5_10 col_6_10 gap_5_10 CELL
Xcell_5_11 row_5_11 row_5_12 col_5_11 col_6_11 gap_5_11 CELL
Xcell_5_12 row_5_12 row_5_13 col_5_12 col_6_12 gap_5_12 CELL
Xcell_5_13 row_5_13 row_5_14 col_5_13 col_6_13 gap_5_13 CELL
Xcell_5_14 row_5_14 row_5_15 col_5_14 col_6_14 gap_5_14 CELL
Xcell_5_15 row_5_15 row_5_16 col_5_15 col_6_15 gap_5_15 CELL
Xcell_5_16 row_5_16 row_5_17 col_5_16 col_6_16 gap_5_16 CELL
Xcell_5_17 row_5_17 row_5_18 col_5_17 col_6_17 gap_5_17 CELL
Xcell_5_18 row_5_18 row_5_19 col_5_18 col_6_18 gap_5_18 CELL
Xcell_5_19 row_5_19 row_5_20 col_5_19 col_6_19 gap_5_19 CELL
Xcell_5_20 row_5_20 row_5_21 col_5_20 col_6_20 gap_5_20 CELL
Xcell_5_21 row_5_21 row_5_22 col_5_21 col_6_21 gap_5_21 CELL
Xcell_5_22 row_5_22 row_5_23 col_5_22 col_6_22 gap_5_22 CELL
Xcell_5_23 row_5_23 row_5_24 col_5_23 col_6_23 gap_5_23 CELL
Xcell_5_24 row_5_24 row_5_25 col_5_24 col_6_24 gap_5_24 CELL
Xcell_5_25 row_5_25 row_5_26 col_5_25 col_6_25 gap_5_25 CELL
Xcell_5_26 row_5_26 row_5_27 col_5_26 col_6_26 gap_5_26 CELL
Xcell_5_27 row_5_27 row_5_28 col_5_27 col_6_27 gap_5_27 CELL
Xcell_5_28 row_5_28 row_5_29 col_5_28 col_6_28 gap_5_28 CELL
Xcell_5_29 row_5_29 row_5_30 col_5_29 col_6_29 gap_5_29 CELL
Xcell_5_30 row_5_30 row_5_31 col_5_30 col_6_30 gap_5_30 CELL
Xcell_5_31 row_5_31 row_5_32 col_5_31 col_6_31 gap_5_31 CELL
Xcell_6_0 row_6_0 row_6_1 col_6_0 col_7_0 gap_6_0 CELL
Xcell_6_1 row_6_1 row_6_2 col_6_1 col_7_1 gap_6_1 CELL
Xcell_6_2 row_6_2 row_6_3 col_6_2 col_7_2 gap_6_2 CELL
Xcell_6_3 row_6_3 row_6_4 col_6_3 col_7_3 gap_6_3 CELL
Xcell_6_4 row_6_4 row_6_5 col_6_4 col_7_4 gap_6_4 CELL
Xcell_6_5 row_6_5 row_6_6 col_6_5 col_7_5 gap_6_5 CELL
Xcell_6_6 row_6_6 row_6_7 col_6_6 col_7_6 gap_6_6 CELL
Xcell_6_7 row_6_7 row_6_8 col_6_7 col_7_7 gap_6_7 CELL
Xcell_6_8 row_6_8 row_6_9 col_6_8 col_7_8 gap_6_8 CELL
Xcell_6_9 row_6_9 row_6_10 col_6_9 col_7_9 gap_6_9 CELL
Xcell_6_10 row_6_10 row_6_11 col_6_10 col_7_10 gap_6_10 CELL
Xcell_6_11 row_6_11 row_6_12 col_6_11 col_7_11 gap_6_11 CELL
Xcell_6_12 row_6_12 row_6_13 col_6_12 col_7_12 gap_6_12 CELL
Xcell_6_13 row_6_13 row_6_14 col_6_13 col_7_13 gap_6_13 CELL
Xcell_6_14 row_6_14 row_6_15 col_6_14 col_7_14 gap_6_14 CELL
Xcell_6_15 row_6_15 row_6_16 col_6_15 col_7_15 gap_6_15 CELL
Xcell_6_16 row_6_16 row_6_17 col_6_16 col_7_16 gap_6_16 CELL
Xcell_6_17 row_6_17 row_6_18 col_6_17 col_7_17 gap_6_17 CELL
Xcell_6_18 row_6_18 row_6_19 col_6_18 col_7_18 gap_6_18 CELL
Xcell_6_19 row_6_19 row_6_20 col_6_19 col_7_19 gap_6_19 CELL
Xcell_6_20 row_6_20 row_6_21 col_6_20 col_7_20 gap_6_20 CELL
Xcell_6_21 row_6_21 row_6_22 col_6_21 col_7_21 gap_6_21 CELL
Xcell_6_22 row_6_22 row_6_23 col_6_22 col_7_22 gap_6_22 CELL
Xcell_6_23 row_6_23 row_6_24 col_6_23 col_7_23 gap_6_23 CELL
Xcell_6_24 row_6_24 row_6_25 col_6_24 col_7_24 gap_6_24 CELL
Xcell_6_25 row_6_25 row_6_26 col_6_25 col_7_25 gap_6_25 CELL
Xcell_6_26 row_6_26 row_6_27 col_6_26 col_7_26 gap_6_26 CELL
Xcell_6_27 row_6_27 row_6_28 col_6_27 col_7_27 gap_6_27 CELL
Xcell_6_28 row_6_28 row_6_29 col_6_28 col_7_28 gap_6_28 CELL
Xcell_6_29 row_6_29 row_6_30 col_6_29 col_7_29 gap_6_29 CELL
Xcell_6_30 row_6_30 row_6_31 col_6_30 col_7_30 gap_6_30 CELL
Xcell_6_31 row_6_31 row_6_32 col_6_31 col_7_31 gap_6_31 CELL
Xcell_7_0 row_7_0 row_7_1 col_7_0 col_8_0 gap_7_0 CELL
Xcell_7_1 row_7_1 row_7_2 col_7_1 col_8_1 gap_7_1 CELL
Xcell_7_2 row_7_2 row_7_3 col_7_2 col_8_2 gap_7_2 CELL
Xcell_7_3 row_7_3 row_7_4 col_7_3 col_8_3 gap_7_3 CELL
Xcell_7_4 row_7_4 row_7_5 col_7_4 col_8_4 gap_7_4 CELL
Xcell_7_5 row_7_5 row_7_6 col_7_5 col_8_5 gap_7_5 CELL
Xcell_7_6 row_7_6 row_7_7 col_7_6 col_8_6 gap_7_6 CELL
Xcell_7_7 row_7_7 row_7_8 col_7_7 col_8_7 gap_7_7 CELL
Xcell_7_8 row_7_8 row_7_9 col_7_8 col_8_8 gap_7_8 CELL
Xcell_7_9 row_7_9 row_7_10 col_7_9 col_8_9 gap_7_9 CELL
Xcell_7_10 row_7_10 row_7_11 col_7_10 col_8_10 gap_7_10 CELL
Xcell_7_11 row_7_11 row_7_12 col_7_11 col_8_11 gap_7_11 CELL
Xcell_7_12 row_7_12 row_7_13 col_7_12 col_8_12 gap_7_12 CELL
Xcell_7_13 row_7_13 row_7_14 col_7_13 col_8_13 gap_7_13 CELL
Xcell_7_14 row_7_14 row_7_15 col_7_14 col_8_14 gap_7_14 CELL
Xcell_7_15 row_7_15 row_7_16 col_7_15 col_8_15 gap_7_15 CELL
Xcell_7_16 row_7_16 row_7_17 col_7_16 col_8_16 gap_7_16 CELL
Xcell_7_17 row_7_17 row_7_18 col_7_17 col_8_17 gap_7_17 CELL
Xcell_7_18 row_7_18 row_7_19 col_7_18 col_8_18 gap_7_18 CELL
Xcell_7_19 row_7_19 row_7_20 col_7_19 col_8_19 gap_7_19 CELL
Xcell_7_20 row_7_20 row_7_21 col_7_20 col_8_20 gap_7_20 CELL
Xcell_7_21 row_7_21 row_7_22 col_7_21 col_8_21 gap_7_21 CELL
Xcell_7_22 row_7_22 row_7_23 col_7_22 col_8_22 gap_7_22 CELL
Xcell_7_23 row_7_23 row_7_24 col_7_23 col_8_23 gap_7_23 CELL
Xcell_7_24 row_7_24 row_7_25 col_7_24 col_8_24 gap_7_24 CELL
Xcell_7_25 row_7_25 row_7_26 col_7_25 col_8_25 gap_7_25 CELL
Xcell_7_26 row_7_26 row_7_27 col_7_26 col_8_26 gap_7_26 CELL
Xcell_7_27 row_7_27 row_7_28 col_7_27 col_8_27 gap_7_27 CELL
Xcell_7_28 row_7_28 row_7_29 col_7_28 col_8_28 gap_7_28 CELL
Xcell_7_29 row_7_29 row_7_30 col_7_29 col_8_29 gap_7_29 CELL
Xcell_7_30 row_7_30 row_7_31 col_7_30 col_8_30 gap_7_30 CELL
Xcell_7_31 row_7_31 row_7_32 col_7_31 col_8_31 gap_7_31 CELL
Xcell_8_0 row_8_0 row_8_1 col_8_0 col_9_0 gap_8_0 CELL
Xcell_8_1 row_8_1 row_8_2 col_8_1 col_9_1 gap_8_1 CELL
Xcell_8_2 row_8_2 row_8_3 col_8_2 col_9_2 gap_8_2 CELL
Xcell_8_3 row_8_3 row_8_4 col_8_3 col_9_3 gap_8_3 CELL
Xcell_8_4 row_8_4 row_8_5 col_8_4 col_9_4 gap_8_4 CELL
Xcell_8_5 row_8_5 row_8_6 col_8_5 col_9_5 gap_8_5 CELL
Xcell_8_6 row_8_6 row_8_7 col_8_6 col_9_6 gap_8_6 CELL
Xcell_8_7 row_8_7 row_8_8 col_8_7 col_9_7 gap_8_7 CELL
Xcell_8_8 row_8_8 row_8_9 col_8_8 col_9_8 gap_8_8 CELL
Xcell_8_9 row_8_9 row_8_10 col_8_9 col_9_9 gap_8_9 CELL
Xcell_8_10 row_8_10 row_8_11 col_8_10 col_9_10 gap_8_10 CELL
Xcell_8_11 row_8_11 row_8_12 col_8_11 col_9_11 gap_8_11 CELL
Xcell_8_12 row_8_12 row_8_13 col_8_12 col_9_12 gap_8_12 CELL
Xcell_8_13 row_8_13 row_8_14 col_8_13 col_9_13 gap_8_13 CELL
Xcell_8_14 row_8_14 row_8_15 col_8_14 col_9_14 gap_8_14 CELL
Xcell_8_15 row_8_15 row_8_16 col_8_15 col_9_15 gap_8_15 CELL
Xcell_8_16 row_8_16 row_8_17 col_8_16 col_9_16 gap_8_16 CELL
Xcell_8_17 row_8_17 row_8_18 col_8_17 col_9_17 gap_8_17 CELL
Xcell_8_18 row_8_18 row_8_19 col_8_18 col_9_18 gap_8_18 CELL
Xcell_8_19 row_8_19 row_8_20 col_8_19 col_9_19 gap_8_19 CELL
Xcell_8_20 row_8_20 row_8_21 col_8_20 col_9_20 gap_8_20 CELL
Xcell_8_21 row_8_21 row_8_22 col_8_21 col_9_21 gap_8_21 CELL
Xcell_8_22 row_8_22 row_8_23 col_8_22 col_9_22 gap_8_22 CELL
Xcell_8_23 row_8_23 row_8_24 col_8_23 col_9_23 gap_8_23 CELL
Xcell_8_24 row_8_24 row_8_25 col_8_24 col_9_24 gap_8_24 CELL
Xcell_8_25 row_8_25 row_8_26 col_8_25 col_9_25 gap_8_25 CELL
Xcell_8_26 row_8_26 row_8_27 col_8_26 col_9_26 gap_8_26 CELL
Xcell_8_27 row_8_27 row_8_28 col_8_27 col_9_27 gap_8_27 CELL
Xcell_8_28 row_8_28 row_8_29 col_8_28 col_9_28 gap_8_28 CELL
Xcell_8_29 row_8_29 row_8_30 col_8_29 col_9_29 gap_8_29 CELL
Xcell_8_30 row_8_30 row_8_31 col_8_30 col_9_30 gap_8_30 CELL
Xcell_8_31 row_8_31 row_8_32 col_8_31 col_9_31 gap_8_31 CELL
Xcell_9_0 row_9_0 row_9_1 col_9_0 col_10_0 gap_9_0 CELL
Xcell_9_1 row_9_1 row_9_2 col_9_1 col_10_1 gap_9_1 CELL
Xcell_9_2 row_9_2 row_9_3 col_9_2 col_10_2 gap_9_2 CELL
Xcell_9_3 row_9_3 row_9_4 col_9_3 col_10_3 gap_9_3 CELL
Xcell_9_4 row_9_4 row_9_5 col_9_4 col_10_4 gap_9_4 CELL
Xcell_9_5 row_9_5 row_9_6 col_9_5 col_10_5 gap_9_5 CELL
Xcell_9_6 row_9_6 row_9_7 col_9_6 col_10_6 gap_9_6 CELL
Xcell_9_7 row_9_7 row_9_8 col_9_7 col_10_7 gap_9_7 CELL
Xcell_9_8 row_9_8 row_9_9 col_9_8 col_10_8 gap_9_8 CELL
Xcell_9_9 row_9_9 row_9_10 col_9_9 col_10_9 gap_9_9 CELL
Xcell_9_10 row_9_10 row_9_11 col_9_10 col_10_10 gap_9_10 CELL
Xcell_9_11 row_9_11 row_9_12 col_9_11 col_10_11 gap_9_11 CELL
Xcell_9_12 row_9_12 row_9_13 col_9_12 col_10_12 gap_9_12 CELL
Xcell_9_13 row_9_13 row_9_14 col_9_13 col_10_13 gap_9_13 CELL
Xcell_9_14 row_9_14 row_9_15 col_9_14 col_10_14 gap_9_14 CELL
Xcell_9_15 row_9_15 row_9_16 col_9_15 col_10_15 gap_9_15 CELL
Xcell_9_16 row_9_16 row_9_17 col_9_16 col_10_16 gap_9_16 CELL
Xcell_9_17 row_9_17 row_9_18 col_9_17 col_10_17 gap_9_17 CELL
Xcell_9_18 row_9_18 row_9_19 col_9_18 col_10_18 gap_9_18 CELL
Xcell_9_19 row_9_19 row_9_20 col_9_19 col_10_19 gap_9_19 CELL
Xcell_9_20 row_9_20 row_9_21 col_9_20 col_10_20 gap_9_20 CELL
Xcell_9_21 row_9_21 row_9_22 col_9_21 col_10_21 gap_9_21 CELL
Xcell_9_22 row_9_22 row_9_23 col_9_22 col_10_22 gap_9_22 CELL
Xcell_9_23 row_9_23 row_9_24 col_9_23 col_10_23 gap_9_23 CELL
Xcell_9_24 row_9_24 row_9_25 col_9_24 col_10_24 gap_9_24 CELL
Xcell_9_25 row_9_25 row_9_26 col_9_25 col_10_25 gap_9_25 CELL
Xcell_9_26 row_9_26 row_9_27 col_9_26 col_10_26 gap_9_26 CELL
Xcell_9_27 row_9_27 row_9_28 col_9_27 col_10_27 gap_9_27 CELL
Xcell_9_28 row_9_28 row_9_29 col_9_28 col_10_28 gap_9_28 CELL
Xcell_9_29 row_9_29 row_9_30 col_9_29 col_10_29 gap_9_29 CELL
Xcell_9_30 row_9_30 row_9_31 col_9_30 col_10_30 gap_9_30 CELL
Xcell_9_31 row_9_31 row_9_32 col_9_31 col_10_31 gap_9_31 CELL
Xcell_10_0 row_10_0 row_10_1 col_10_0 col_11_0 gap_10_0 CELL
Xcell_10_1 row_10_1 row_10_2 col_10_1 col_11_1 gap_10_1 CELL
Xcell_10_2 row_10_2 row_10_3 col_10_2 col_11_2 gap_10_2 CELL
Xcell_10_3 row_10_3 row_10_4 col_10_3 col_11_3 gap_10_3 CELL
Xcell_10_4 row_10_4 row_10_5 col_10_4 col_11_4 gap_10_4 CELL
Xcell_10_5 row_10_5 row_10_6 col_10_5 col_11_5 gap_10_5 CELL
Xcell_10_6 row_10_6 row_10_7 col_10_6 col_11_6 gap_10_6 CELL
Xcell_10_7 row_10_7 row_10_8 col_10_7 col_11_7 gap_10_7 CELL
Xcell_10_8 row_10_8 row_10_9 col_10_8 col_11_8 gap_10_8 CELL
Xcell_10_9 row_10_9 row_10_10 col_10_9 col_11_9 gap_10_9 CELL
Xcell_10_10 row_10_10 row_10_11 col_10_10 col_11_10 gap_10_10 CELL
Xcell_10_11 row_10_11 row_10_12 col_10_11 col_11_11 gap_10_11 CELL
Xcell_10_12 row_10_12 row_10_13 col_10_12 col_11_12 gap_10_12 CELL
Xcell_10_13 row_10_13 row_10_14 col_10_13 col_11_13 gap_10_13 CELL
Xcell_10_14 row_10_14 row_10_15 col_10_14 col_11_14 gap_10_14 CELL
Xcell_10_15 row_10_15 row_10_16 col_10_15 col_11_15 gap_10_15 CELL
Xcell_10_16 row_10_16 row_10_17 col_10_16 col_11_16 gap_10_16 CELL
Xcell_10_17 row_10_17 row_10_18 col_10_17 col_11_17 gap_10_17 CELL
Xcell_10_18 row_10_18 row_10_19 col_10_18 col_11_18 gap_10_18 CELL
Xcell_10_19 row_10_19 row_10_20 col_10_19 col_11_19 gap_10_19 CELL
Xcell_10_20 row_10_20 row_10_21 col_10_20 col_11_20 gap_10_20 CELL
Xcell_10_21 row_10_21 row_10_22 col_10_21 col_11_21 gap_10_21 CELL
Xcell_10_22 row_10_22 row_10_23 col_10_22 col_11_22 gap_10_22 CELL
Xcell_10_23 row_10_23 row_10_24 col_10_23 col_11_23 gap_10_23 CELL
Xcell_10_24 row_10_24 row_10_25 col_10_24 col_11_24 gap_10_24 CELL
Xcell_10_25 row_10_25 row_10_26 col_10_25 col_11_25 gap_10_25 CELL
Xcell_10_26 row_10_26 row_10_27 col_10_26 col_11_26 gap_10_26 CELL
Xcell_10_27 row_10_27 row_10_28 col_10_27 col_11_27 gap_10_27 CELL
Xcell_10_28 row_10_28 row_10_29 col_10_28 col_11_28 gap_10_28 CELL
Xcell_10_29 row_10_29 row_10_30 col_10_29 col_11_29 gap_10_29 CELL
Xcell_10_30 row_10_30 row_10_31 col_10_30 col_11_30 gap_10_30 CELL
Xcell_10_31 row_10_31 row_10_32 col_10_31 col_11_31 gap_10_31 CELL
Xcell_11_0 row_11_0 row_11_1 col_11_0 col_12_0 gap_11_0 CELL
Xcell_11_1 row_11_1 row_11_2 col_11_1 col_12_1 gap_11_1 CELL
Xcell_11_2 row_11_2 row_11_3 col_11_2 col_12_2 gap_11_2 CELL
Xcell_11_3 row_11_3 row_11_4 col_11_3 col_12_3 gap_11_3 CELL
Xcell_11_4 row_11_4 row_11_5 col_11_4 col_12_4 gap_11_4 CELL
Xcell_11_5 row_11_5 row_11_6 col_11_5 col_12_5 gap_11_5 CELL
Xcell_11_6 row_11_6 row_11_7 col_11_6 col_12_6 gap_11_6 CELL
Xcell_11_7 row_11_7 row_11_8 col_11_7 col_12_7 gap_11_7 CELL
Xcell_11_8 row_11_8 row_11_9 col_11_8 col_12_8 gap_11_8 CELL
Xcell_11_9 row_11_9 row_11_10 col_11_9 col_12_9 gap_11_9 CELL
Xcell_11_10 row_11_10 row_11_11 col_11_10 col_12_10 gap_11_10 CELL
Xcell_11_11 row_11_11 row_11_12 col_11_11 col_12_11 gap_11_11 CELL
Xcell_11_12 row_11_12 row_11_13 col_11_12 col_12_12 gap_11_12 CELL
Xcell_11_13 row_11_13 row_11_14 col_11_13 col_12_13 gap_11_13 CELL
Xcell_11_14 row_11_14 row_11_15 col_11_14 col_12_14 gap_11_14 CELL
Xcell_11_15 row_11_15 row_11_16 col_11_15 col_12_15 gap_11_15 CELL
Xcell_11_16 row_11_16 row_11_17 col_11_16 col_12_16 gap_11_16 CELL
Xcell_11_17 row_11_17 row_11_18 col_11_17 col_12_17 gap_11_17 CELL
Xcell_11_18 row_11_18 row_11_19 col_11_18 col_12_18 gap_11_18 CELL
Xcell_11_19 row_11_19 row_11_20 col_11_19 col_12_19 gap_11_19 CELL
Xcell_11_20 row_11_20 row_11_21 col_11_20 col_12_20 gap_11_20 CELL
Xcell_11_21 row_11_21 row_11_22 col_11_21 col_12_21 gap_11_21 CELL
Xcell_11_22 row_11_22 row_11_23 col_11_22 col_12_22 gap_11_22 CELL
Xcell_11_23 row_11_23 row_11_24 col_11_23 col_12_23 gap_11_23 CELL
Xcell_11_24 row_11_24 row_11_25 col_11_24 col_12_24 gap_11_24 CELL
Xcell_11_25 row_11_25 row_11_26 col_11_25 col_12_25 gap_11_25 CELL
Xcell_11_26 row_11_26 row_11_27 col_11_26 col_12_26 gap_11_26 CELL
Xcell_11_27 row_11_27 row_11_28 col_11_27 col_12_27 gap_11_27 CELL
Xcell_11_28 row_11_28 row_11_29 col_11_28 col_12_28 gap_11_28 CELL
Xcell_11_29 row_11_29 row_11_30 col_11_29 col_12_29 gap_11_29 CELL
Xcell_11_30 row_11_30 row_11_31 col_11_30 col_12_30 gap_11_30 CELL
Xcell_11_31 row_11_31 row_11_32 col_11_31 col_12_31 gap_11_31 CELL
Xcell_12_0 row_12_0 row_12_1 col_12_0 col_13_0 gap_12_0 CELL
Xcell_12_1 row_12_1 row_12_2 col_12_1 col_13_1 gap_12_1 CELL
Xcell_12_2 row_12_2 row_12_3 col_12_2 col_13_2 gap_12_2 CELL
Xcell_12_3 row_12_3 row_12_4 col_12_3 col_13_3 gap_12_3 CELL
Xcell_12_4 row_12_4 row_12_5 col_12_4 col_13_4 gap_12_4 CELL
Xcell_12_5 row_12_5 row_12_6 col_12_5 col_13_5 gap_12_5 CELL
Xcell_12_6 row_12_6 row_12_7 col_12_6 col_13_6 gap_12_6 CELL
Xcell_12_7 row_12_7 row_12_8 col_12_7 col_13_7 gap_12_7 CELL
Xcell_12_8 row_12_8 row_12_9 col_12_8 col_13_8 gap_12_8 CELL
Xcell_12_9 row_12_9 row_12_10 col_12_9 col_13_9 gap_12_9 CELL
Xcell_12_10 row_12_10 row_12_11 col_12_10 col_13_10 gap_12_10 CELL
Xcell_12_11 row_12_11 row_12_12 col_12_11 col_13_11 gap_12_11 CELL
Xcell_12_12 row_12_12 row_12_13 col_12_12 col_13_12 gap_12_12 CELL
Xcell_12_13 row_12_13 row_12_14 col_12_13 col_13_13 gap_12_13 CELL
Xcell_12_14 row_12_14 row_12_15 col_12_14 col_13_14 gap_12_14 CELL
Xcell_12_15 row_12_15 row_12_16 col_12_15 col_13_15 gap_12_15 CELL
Xcell_12_16 row_12_16 row_12_17 col_12_16 col_13_16 gap_12_16 CELL
Xcell_12_17 row_12_17 row_12_18 col_12_17 col_13_17 gap_12_17 CELL
Xcell_12_18 row_12_18 row_12_19 col_12_18 col_13_18 gap_12_18 CELL
Xcell_12_19 row_12_19 row_12_20 col_12_19 col_13_19 gap_12_19 CELL
Xcell_12_20 row_12_20 row_12_21 col_12_20 col_13_20 gap_12_20 CELL
Xcell_12_21 row_12_21 row_12_22 col_12_21 col_13_21 gap_12_21 CELL
Xcell_12_22 row_12_22 row_12_23 col_12_22 col_13_22 gap_12_22 CELL
Xcell_12_23 row_12_23 row_12_24 col_12_23 col_13_23 gap_12_23 CELL
Xcell_12_24 row_12_24 row_12_25 col_12_24 col_13_24 gap_12_24 CELL
Xcell_12_25 row_12_25 row_12_26 col_12_25 col_13_25 gap_12_25 CELL
Xcell_12_26 row_12_26 row_12_27 col_12_26 col_13_26 gap_12_26 CELL
Xcell_12_27 row_12_27 row_12_28 col_12_27 col_13_27 gap_12_27 CELL
Xcell_12_28 row_12_28 row_12_29 col_12_28 col_13_28 gap_12_28 CELL
Xcell_12_29 row_12_29 row_12_30 col_12_29 col_13_29 gap_12_29 CELL
Xcell_12_30 row_12_30 row_12_31 col_12_30 col_13_30 gap_12_30 CELL
Xcell_12_31 row_12_31 row_12_32 col_12_31 col_13_31 gap_12_31 CELL
Xcell_13_0 row_13_0 row_13_1 col_13_0 col_14_0 gap_13_0 CELL
Xcell_13_1 row_13_1 row_13_2 col_13_1 col_14_1 gap_13_1 CELL
Xcell_13_2 row_13_2 row_13_3 col_13_2 col_14_2 gap_13_2 CELL
Xcell_13_3 row_13_3 row_13_4 col_13_3 col_14_3 gap_13_3 CELL
Xcell_13_4 row_13_4 row_13_5 col_13_4 col_14_4 gap_13_4 CELL
Xcell_13_5 row_13_5 row_13_6 col_13_5 col_14_5 gap_13_5 CELL
Xcell_13_6 row_13_6 row_13_7 col_13_6 col_14_6 gap_13_6 CELL
Xcell_13_7 row_13_7 row_13_8 col_13_7 col_14_7 gap_13_7 CELL
Xcell_13_8 row_13_8 row_13_9 col_13_8 col_14_8 gap_13_8 CELL
Xcell_13_9 row_13_9 row_13_10 col_13_9 col_14_9 gap_13_9 CELL
Xcell_13_10 row_13_10 row_13_11 col_13_10 col_14_10 gap_13_10 CELL
Xcell_13_11 row_13_11 row_13_12 col_13_11 col_14_11 gap_13_11 CELL
Xcell_13_12 row_13_12 row_13_13 col_13_12 col_14_12 gap_13_12 CELL
Xcell_13_13 row_13_13 row_13_14 col_13_13 col_14_13 gap_13_13 CELL
Xcell_13_14 row_13_14 row_13_15 col_13_14 col_14_14 gap_13_14 CELL
Xcell_13_15 row_13_15 row_13_16 col_13_15 col_14_15 gap_13_15 CELL
Xcell_13_16 row_13_16 row_13_17 col_13_16 col_14_16 gap_13_16 CELL
Xcell_13_17 row_13_17 row_13_18 col_13_17 col_14_17 gap_13_17 CELL
Xcell_13_18 row_13_18 row_13_19 col_13_18 col_14_18 gap_13_18 CELL
Xcell_13_19 row_13_19 row_13_20 col_13_19 col_14_19 gap_13_19 CELL
Xcell_13_20 row_13_20 row_13_21 col_13_20 col_14_20 gap_13_20 CELL
Xcell_13_21 row_13_21 row_13_22 col_13_21 col_14_21 gap_13_21 CELL
Xcell_13_22 row_13_22 row_13_23 col_13_22 col_14_22 gap_13_22 CELL
Xcell_13_23 row_13_23 row_13_24 col_13_23 col_14_23 gap_13_23 CELL
Xcell_13_24 row_13_24 row_13_25 col_13_24 col_14_24 gap_13_24 CELL
Xcell_13_25 row_13_25 row_13_26 col_13_25 col_14_25 gap_13_25 CELL
Xcell_13_26 row_13_26 row_13_27 col_13_26 col_14_26 gap_13_26 CELL
Xcell_13_27 row_13_27 row_13_28 col_13_27 col_14_27 gap_13_27 CELL
Xcell_13_28 row_13_28 row_13_29 col_13_28 col_14_28 gap_13_28 CELL
Xcell_13_29 row_13_29 row_13_30 col_13_29 col_14_29 gap_13_29 CELL
Xcell_13_30 row_13_30 row_13_31 col_13_30 col_14_30 gap_13_30 CELL
Xcell_13_31 row_13_31 row_13_32 col_13_31 col_14_31 gap_13_31 CELL
Xcell_14_0 row_14_0 row_14_1 col_14_0 col_15_0 gap_14_0 CELL
Xcell_14_1 row_14_1 row_14_2 col_14_1 col_15_1 gap_14_1 CELL
Xcell_14_2 row_14_2 row_14_3 col_14_2 col_15_2 gap_14_2 CELL
Xcell_14_3 row_14_3 row_14_4 col_14_3 col_15_3 gap_14_3 CELL
Xcell_14_4 row_14_4 row_14_5 col_14_4 col_15_4 gap_14_4 CELL
Xcell_14_5 row_14_5 row_14_6 col_14_5 col_15_5 gap_14_5 CELL
Xcell_14_6 row_14_6 row_14_7 col_14_6 col_15_6 gap_14_6 CELL
Xcell_14_7 row_14_7 row_14_8 col_14_7 col_15_7 gap_14_7 CELL
Xcell_14_8 row_14_8 row_14_9 col_14_8 col_15_8 gap_14_8 CELL
Xcell_14_9 row_14_9 row_14_10 col_14_9 col_15_9 gap_14_9 CELL
Xcell_14_10 row_14_10 row_14_11 col_14_10 col_15_10 gap_14_10 CELL
Xcell_14_11 row_14_11 row_14_12 col_14_11 col_15_11 gap_14_11 CELL
Xcell_14_12 row_14_12 row_14_13 col_14_12 col_15_12 gap_14_12 CELL
Xcell_14_13 row_14_13 row_14_14 col_14_13 col_15_13 gap_14_13 CELL
Xcell_14_14 row_14_14 row_14_15 col_14_14 col_15_14 gap_14_14 CELL
Xcell_14_15 row_14_15 row_14_16 col_14_15 col_15_15 gap_14_15 CELL
Xcell_14_16 row_14_16 row_14_17 col_14_16 col_15_16 gap_14_16 CELL
Xcell_14_17 row_14_17 row_14_18 col_14_17 col_15_17 gap_14_17 CELL
Xcell_14_18 row_14_18 row_14_19 col_14_18 col_15_18 gap_14_18 CELL
Xcell_14_19 row_14_19 row_14_20 col_14_19 col_15_19 gap_14_19 CELL
Xcell_14_20 row_14_20 row_14_21 col_14_20 col_15_20 gap_14_20 CELL
Xcell_14_21 row_14_21 row_14_22 col_14_21 col_15_21 gap_14_21 CELL
Xcell_14_22 row_14_22 row_14_23 col_14_22 col_15_22 gap_14_22 CELL
Xcell_14_23 row_14_23 row_14_24 col_14_23 col_15_23 gap_14_23 CELL
Xcell_14_24 row_14_24 row_14_25 col_14_24 col_15_24 gap_14_24 CELL
Xcell_14_25 row_14_25 row_14_26 col_14_25 col_15_25 gap_14_25 CELL
Xcell_14_26 row_14_26 row_14_27 col_14_26 col_15_26 gap_14_26 CELL
Xcell_14_27 row_14_27 row_14_28 col_14_27 col_15_27 gap_14_27 CELL
Xcell_14_28 row_14_28 row_14_29 col_14_28 col_15_28 gap_14_28 CELL
Xcell_14_29 row_14_29 row_14_30 col_14_29 col_15_29 gap_14_29 CELL
Xcell_14_30 row_14_30 row_14_31 col_14_30 col_15_30 gap_14_30 CELL
Xcell_14_31 row_14_31 row_14_32 col_14_31 col_15_31 gap_14_31 CELL
Xcell_15_0 row_15_0 row_15_1 col_15_0 col_16_0 gap_15_0 CELL
Xcell_15_1 row_15_1 row_15_2 col_15_1 col_16_1 gap_15_1 CELL
Xcell_15_2 row_15_2 row_15_3 col_15_2 col_16_2 gap_15_2 CELL
Xcell_15_3 row_15_3 row_15_4 col_15_3 col_16_3 gap_15_3 CELL
Xcell_15_4 row_15_4 row_15_5 col_15_4 col_16_4 gap_15_4 CELL
Xcell_15_5 row_15_5 row_15_6 col_15_5 col_16_5 gap_15_5 CELL
Xcell_15_6 row_15_6 row_15_7 col_15_6 col_16_6 gap_15_6 CELL
Xcell_15_7 row_15_7 row_15_8 col_15_7 col_16_7 gap_15_7 CELL
Xcell_15_8 row_15_8 row_15_9 col_15_8 col_16_8 gap_15_8 CELL
Xcell_15_9 row_15_9 row_15_10 col_15_9 col_16_9 gap_15_9 CELL
Xcell_15_10 row_15_10 row_15_11 col_15_10 col_16_10 gap_15_10 CELL
Xcell_15_11 row_15_11 row_15_12 col_15_11 col_16_11 gap_15_11 CELL
Xcell_15_12 row_15_12 row_15_13 col_15_12 col_16_12 gap_15_12 CELL
Xcell_15_13 row_15_13 row_15_14 col_15_13 col_16_13 gap_15_13 CELL
Xcell_15_14 row_15_14 row_15_15 col_15_14 col_16_14 gap_15_14 CELL
Xcell_15_15 row_15_15 row_15_16 col_15_15 col_16_15 gap_15_15 CELL
Xcell_15_16 row_15_16 row_15_17 col_15_16 col_16_16 gap_15_16 CELL
Xcell_15_17 row_15_17 row_15_18 col_15_17 col_16_17 gap_15_17 CELL
Xcell_15_18 row_15_18 row_15_19 col_15_18 col_16_18 gap_15_18 CELL
Xcell_15_19 row_15_19 row_15_20 col_15_19 col_16_19 gap_15_19 CELL
Xcell_15_20 row_15_20 row_15_21 col_15_20 col_16_20 gap_15_20 CELL
Xcell_15_21 row_15_21 row_15_22 col_15_21 col_16_21 gap_15_21 CELL
Xcell_15_22 row_15_22 row_15_23 col_15_22 col_16_22 gap_15_22 CELL
Xcell_15_23 row_15_23 row_15_24 col_15_23 col_16_23 gap_15_23 CELL
Xcell_15_24 row_15_24 row_15_25 col_15_24 col_16_24 gap_15_24 CELL
Xcell_15_25 row_15_25 row_15_26 col_15_25 col_16_25 gap_15_25 CELL
Xcell_15_26 row_15_26 row_15_27 col_15_26 col_16_26 gap_15_26 CELL
Xcell_15_27 row_15_27 row_15_28 col_15_27 col_16_27 gap_15_27 CELL
Xcell_15_28 row_15_28 row_15_29 col_15_28 col_16_28 gap_15_28 CELL
Xcell_15_29 row_15_29 row_15_30 col_15_29 col_16_29 gap_15_29 CELL
Xcell_15_30 row_15_30 row_15_31 col_15_30 col_16_30 gap_15_30 CELL
Xcell_15_31 row_15_31 row_15_32 col_15_31 col_16_31 gap_15_31 CELL
Xcell_16_0 row_16_0 row_16_1 col_16_0 col_17_0 gap_16_0 CELL
Xcell_16_1 row_16_1 row_16_2 col_16_1 col_17_1 gap_16_1 CELL
Xcell_16_2 row_16_2 row_16_3 col_16_2 col_17_2 gap_16_2 CELL
Xcell_16_3 row_16_3 row_16_4 col_16_3 col_17_3 gap_16_3 CELL
Xcell_16_4 row_16_4 row_16_5 col_16_4 col_17_4 gap_16_4 CELL
Xcell_16_5 row_16_5 row_16_6 col_16_5 col_17_5 gap_16_5 CELL
Xcell_16_6 row_16_6 row_16_7 col_16_6 col_17_6 gap_16_6 CELL
Xcell_16_7 row_16_7 row_16_8 col_16_7 col_17_7 gap_16_7 CELL
Xcell_16_8 row_16_8 row_16_9 col_16_8 col_17_8 gap_16_8 CELL
Xcell_16_9 row_16_9 row_16_10 col_16_9 col_17_9 gap_16_9 CELL
Xcell_16_10 row_16_10 row_16_11 col_16_10 col_17_10 gap_16_10 CELL
Xcell_16_11 row_16_11 row_16_12 col_16_11 col_17_11 gap_16_11 CELL
Xcell_16_12 row_16_12 row_16_13 col_16_12 col_17_12 gap_16_12 CELL
Xcell_16_13 row_16_13 row_16_14 col_16_13 col_17_13 gap_16_13 CELL
Xcell_16_14 row_16_14 row_16_15 col_16_14 col_17_14 gap_16_14 CELL
Xcell_16_15 row_16_15 row_16_16 col_16_15 col_17_15 gap_16_15 CELL
Xcell_16_16 row_16_16 row_16_17 col_16_16 col_17_16 gap_16_16 CELL
Xcell_16_17 row_16_17 row_16_18 col_16_17 col_17_17 gap_16_17 CELL
Xcell_16_18 row_16_18 row_16_19 col_16_18 col_17_18 gap_16_18 CELL
Xcell_16_19 row_16_19 row_16_20 col_16_19 col_17_19 gap_16_19 CELL
Xcell_16_20 row_16_20 row_16_21 col_16_20 col_17_20 gap_16_20 CELL
Xcell_16_21 row_16_21 row_16_22 col_16_21 col_17_21 gap_16_21 CELL
Xcell_16_22 row_16_22 row_16_23 col_16_22 col_17_22 gap_16_22 CELL
Xcell_16_23 row_16_23 row_16_24 col_16_23 col_17_23 gap_16_23 CELL
Xcell_16_24 row_16_24 row_16_25 col_16_24 col_17_24 gap_16_24 CELL
Xcell_16_25 row_16_25 row_16_26 col_16_25 col_17_25 gap_16_25 CELL
Xcell_16_26 row_16_26 row_16_27 col_16_26 col_17_26 gap_16_26 CELL
Xcell_16_27 row_16_27 row_16_28 col_16_27 col_17_27 gap_16_27 CELL
Xcell_16_28 row_16_28 row_16_29 col_16_28 col_17_28 gap_16_28 CELL
Xcell_16_29 row_16_29 row_16_30 col_16_29 col_17_29 gap_16_29 CELL
Xcell_16_30 row_16_30 row_16_31 col_16_30 col_17_30 gap_16_30 CELL
Xcell_16_31 row_16_31 row_16_32 col_16_31 col_17_31 gap_16_31 CELL
Xcell_17_0 row_17_0 row_17_1 col_17_0 col_18_0 gap_17_0 CELL
Xcell_17_1 row_17_1 row_17_2 col_17_1 col_18_1 gap_17_1 CELL
Xcell_17_2 row_17_2 row_17_3 col_17_2 col_18_2 gap_17_2 CELL
Xcell_17_3 row_17_3 row_17_4 col_17_3 col_18_3 gap_17_3 CELL
Xcell_17_4 row_17_4 row_17_5 col_17_4 col_18_4 gap_17_4 CELL
Xcell_17_5 row_17_5 row_17_6 col_17_5 col_18_5 gap_17_5 CELL
Xcell_17_6 row_17_6 row_17_7 col_17_6 col_18_6 gap_17_6 CELL
Xcell_17_7 row_17_7 row_17_8 col_17_7 col_18_7 gap_17_7 CELL
Xcell_17_8 row_17_8 row_17_9 col_17_8 col_18_8 gap_17_8 CELL
Xcell_17_9 row_17_9 row_17_10 col_17_9 col_18_9 gap_17_9 CELL
Xcell_17_10 row_17_10 row_17_11 col_17_10 col_18_10 gap_17_10 CELL
Xcell_17_11 row_17_11 row_17_12 col_17_11 col_18_11 gap_17_11 CELL
Xcell_17_12 row_17_12 row_17_13 col_17_12 col_18_12 gap_17_12 CELL
Xcell_17_13 row_17_13 row_17_14 col_17_13 col_18_13 gap_17_13 CELL
Xcell_17_14 row_17_14 row_17_15 col_17_14 col_18_14 gap_17_14 CELL
Xcell_17_15 row_17_15 row_17_16 col_17_15 col_18_15 gap_17_15 CELL
Xcell_17_16 row_17_16 row_17_17 col_17_16 col_18_16 gap_17_16 CELL
Xcell_17_17 row_17_17 row_17_18 col_17_17 col_18_17 gap_17_17 CELL
Xcell_17_18 row_17_18 row_17_19 col_17_18 col_18_18 gap_17_18 CELL
Xcell_17_19 row_17_19 row_17_20 col_17_19 col_18_19 gap_17_19 CELL
Xcell_17_20 row_17_20 row_17_21 col_17_20 col_18_20 gap_17_20 CELL
Xcell_17_21 row_17_21 row_17_22 col_17_21 col_18_21 gap_17_21 CELL
Xcell_17_22 row_17_22 row_17_23 col_17_22 col_18_22 gap_17_22 CELL
Xcell_17_23 row_17_23 row_17_24 col_17_23 col_18_23 gap_17_23 CELL
Xcell_17_24 row_17_24 row_17_25 col_17_24 col_18_24 gap_17_24 CELL
Xcell_17_25 row_17_25 row_17_26 col_17_25 col_18_25 gap_17_25 CELL
Xcell_17_26 row_17_26 row_17_27 col_17_26 col_18_26 gap_17_26 CELL
Xcell_17_27 row_17_27 row_17_28 col_17_27 col_18_27 gap_17_27 CELL
Xcell_17_28 row_17_28 row_17_29 col_17_28 col_18_28 gap_17_28 CELL
Xcell_17_29 row_17_29 row_17_30 col_17_29 col_18_29 gap_17_29 CELL
Xcell_17_30 row_17_30 row_17_31 col_17_30 col_18_30 gap_17_30 CELL
Xcell_17_31 row_17_31 row_17_32 col_17_31 col_18_31 gap_17_31 CELL
Xcell_18_0 row_18_0 row_18_1 col_18_0 col_19_0 gap_18_0 CELL
Xcell_18_1 row_18_1 row_18_2 col_18_1 col_19_1 gap_18_1 CELL
Xcell_18_2 row_18_2 row_18_3 col_18_2 col_19_2 gap_18_2 CELL
Xcell_18_3 row_18_3 row_18_4 col_18_3 col_19_3 gap_18_3 CELL
Xcell_18_4 row_18_4 row_18_5 col_18_4 col_19_4 gap_18_4 CELL
Xcell_18_5 row_18_5 row_18_6 col_18_5 col_19_5 gap_18_5 CELL
Xcell_18_6 row_18_6 row_18_7 col_18_6 col_19_6 gap_18_6 CELL
Xcell_18_7 row_18_7 row_18_8 col_18_7 col_19_7 gap_18_7 CELL
Xcell_18_8 row_18_8 row_18_9 col_18_8 col_19_8 gap_18_8 CELL
Xcell_18_9 row_18_9 row_18_10 col_18_9 col_19_9 gap_18_9 CELL
Xcell_18_10 row_18_10 row_18_11 col_18_10 col_19_10 gap_18_10 CELL
Xcell_18_11 row_18_11 row_18_12 col_18_11 col_19_11 gap_18_11 CELL
Xcell_18_12 row_18_12 row_18_13 col_18_12 col_19_12 gap_18_12 CELL
Xcell_18_13 row_18_13 row_18_14 col_18_13 col_19_13 gap_18_13 CELL
Xcell_18_14 row_18_14 row_18_15 col_18_14 col_19_14 gap_18_14 CELL
Xcell_18_15 row_18_15 row_18_16 col_18_15 col_19_15 gap_18_15 CELL
Xcell_18_16 row_18_16 row_18_17 col_18_16 col_19_16 gap_18_16 CELL
Xcell_18_17 row_18_17 row_18_18 col_18_17 col_19_17 gap_18_17 CELL
Xcell_18_18 row_18_18 row_18_19 col_18_18 col_19_18 gap_18_18 CELL
Xcell_18_19 row_18_19 row_18_20 col_18_19 col_19_19 gap_18_19 CELL
Xcell_18_20 row_18_20 row_18_21 col_18_20 col_19_20 gap_18_20 CELL
Xcell_18_21 row_18_21 row_18_22 col_18_21 col_19_21 gap_18_21 CELL
Xcell_18_22 row_18_22 row_18_23 col_18_22 col_19_22 gap_18_22 CELL
Xcell_18_23 row_18_23 row_18_24 col_18_23 col_19_23 gap_18_23 CELL
Xcell_18_24 row_18_24 row_18_25 col_18_24 col_19_24 gap_18_24 CELL
Xcell_18_25 row_18_25 row_18_26 col_18_25 col_19_25 gap_18_25 CELL
Xcell_18_26 row_18_26 row_18_27 col_18_26 col_19_26 gap_18_26 CELL
Xcell_18_27 row_18_27 row_18_28 col_18_27 col_19_27 gap_18_27 CELL
Xcell_18_28 row_18_28 row_18_29 col_18_28 col_19_28 gap_18_28 CELL
Xcell_18_29 row_18_29 row_18_30 col_18_29 col_19_29 gap_18_29 CELL
Xcell_18_30 row_18_30 row_18_31 col_18_30 col_19_30 gap_18_30 CELL
Xcell_18_31 row_18_31 row_18_32 col_18_31 col_19_31 gap_18_31 CELL
Xcell_19_0 row_19_0 row_19_1 col_19_0 col_20_0 gap_19_0 CELL
Xcell_19_1 row_19_1 row_19_2 col_19_1 col_20_1 gap_19_1 CELL
Xcell_19_2 row_19_2 row_19_3 col_19_2 col_20_2 gap_19_2 CELL
Xcell_19_3 row_19_3 row_19_4 col_19_3 col_20_3 gap_19_3 CELL
Xcell_19_4 row_19_4 row_19_5 col_19_4 col_20_4 gap_19_4 CELL
Xcell_19_5 row_19_5 row_19_6 col_19_5 col_20_5 gap_19_5 CELL
Xcell_19_6 row_19_6 row_19_7 col_19_6 col_20_6 gap_19_6 CELL
Xcell_19_7 row_19_7 row_19_8 col_19_7 col_20_7 gap_19_7 CELL
Xcell_19_8 row_19_8 row_19_9 col_19_8 col_20_8 gap_19_8 CELL
Xcell_19_9 row_19_9 row_19_10 col_19_9 col_20_9 gap_19_9 CELL
Xcell_19_10 row_19_10 row_19_11 col_19_10 col_20_10 gap_19_10 CELL
Xcell_19_11 row_19_11 row_19_12 col_19_11 col_20_11 gap_19_11 CELL
Xcell_19_12 row_19_12 row_19_13 col_19_12 col_20_12 gap_19_12 CELL
Xcell_19_13 row_19_13 row_19_14 col_19_13 col_20_13 gap_19_13 CELL
Xcell_19_14 row_19_14 row_19_15 col_19_14 col_20_14 gap_19_14 CELL
Xcell_19_15 row_19_15 row_19_16 col_19_15 col_20_15 gap_19_15 CELL
Xcell_19_16 row_19_16 row_19_17 col_19_16 col_20_16 gap_19_16 CELL
Xcell_19_17 row_19_17 row_19_18 col_19_17 col_20_17 gap_19_17 CELL
Xcell_19_18 row_19_18 row_19_19 col_19_18 col_20_18 gap_19_18 CELL
Xcell_19_19 row_19_19 row_19_20 col_19_19 col_20_19 gap_19_19 CELL
Xcell_19_20 row_19_20 row_19_21 col_19_20 col_20_20 gap_19_20 CELL
Xcell_19_21 row_19_21 row_19_22 col_19_21 col_20_21 gap_19_21 CELL
Xcell_19_22 row_19_22 row_19_23 col_19_22 col_20_22 gap_19_22 CELL
Xcell_19_23 row_19_23 row_19_24 col_19_23 col_20_23 gap_19_23 CELL
Xcell_19_24 row_19_24 row_19_25 col_19_24 col_20_24 gap_19_24 CELL
Xcell_19_25 row_19_25 row_19_26 col_19_25 col_20_25 gap_19_25 CELL
Xcell_19_26 row_19_26 row_19_27 col_19_26 col_20_26 gap_19_26 CELL
Xcell_19_27 row_19_27 row_19_28 col_19_27 col_20_27 gap_19_27 CELL
Xcell_19_28 row_19_28 row_19_29 col_19_28 col_20_28 gap_19_28 CELL
Xcell_19_29 row_19_29 row_19_30 col_19_29 col_20_29 gap_19_29 CELL
Xcell_19_30 row_19_30 row_19_31 col_19_30 col_20_30 gap_19_30 CELL
Xcell_19_31 row_19_31 row_19_32 col_19_31 col_20_31 gap_19_31 CELL
Xcell_20_0 row_20_0 row_20_1 col_20_0 col_21_0 gap_20_0 CELL
Xcell_20_1 row_20_1 row_20_2 col_20_1 col_21_1 gap_20_1 CELL
Xcell_20_2 row_20_2 row_20_3 col_20_2 col_21_2 gap_20_2 CELL
Xcell_20_3 row_20_3 row_20_4 col_20_3 col_21_3 gap_20_3 CELL
Xcell_20_4 row_20_4 row_20_5 col_20_4 col_21_4 gap_20_4 CELL
Xcell_20_5 row_20_5 row_20_6 col_20_5 col_21_5 gap_20_5 CELL
Xcell_20_6 row_20_6 row_20_7 col_20_6 col_21_6 gap_20_6 CELL
Xcell_20_7 row_20_7 row_20_8 col_20_7 col_21_7 gap_20_7 CELL
Xcell_20_8 row_20_8 row_20_9 col_20_8 col_21_8 gap_20_8 CELL
Xcell_20_9 row_20_9 row_20_10 col_20_9 col_21_9 gap_20_9 CELL
Xcell_20_10 row_20_10 row_20_11 col_20_10 col_21_10 gap_20_10 CELL
Xcell_20_11 row_20_11 row_20_12 col_20_11 col_21_11 gap_20_11 CELL
Xcell_20_12 row_20_12 row_20_13 col_20_12 col_21_12 gap_20_12 CELL
Xcell_20_13 row_20_13 row_20_14 col_20_13 col_21_13 gap_20_13 CELL
Xcell_20_14 row_20_14 row_20_15 col_20_14 col_21_14 gap_20_14 CELL
Xcell_20_15 row_20_15 row_20_16 col_20_15 col_21_15 gap_20_15 CELL
Xcell_20_16 row_20_16 row_20_17 col_20_16 col_21_16 gap_20_16 CELL
Xcell_20_17 row_20_17 row_20_18 col_20_17 col_21_17 gap_20_17 CELL
Xcell_20_18 row_20_18 row_20_19 col_20_18 col_21_18 gap_20_18 CELL
Xcell_20_19 row_20_19 row_20_20 col_20_19 col_21_19 gap_20_19 CELL
Xcell_20_20 row_20_20 row_20_21 col_20_20 col_21_20 gap_20_20 CELL
Xcell_20_21 row_20_21 row_20_22 col_20_21 col_21_21 gap_20_21 CELL
Xcell_20_22 row_20_22 row_20_23 col_20_22 col_21_22 gap_20_22 CELL
Xcell_20_23 row_20_23 row_20_24 col_20_23 col_21_23 gap_20_23 CELL
Xcell_20_24 row_20_24 row_20_25 col_20_24 col_21_24 gap_20_24 CELL
Xcell_20_25 row_20_25 row_20_26 col_20_25 col_21_25 gap_20_25 CELL
Xcell_20_26 row_20_26 row_20_27 col_20_26 col_21_26 gap_20_26 CELL
Xcell_20_27 row_20_27 row_20_28 col_20_27 col_21_27 gap_20_27 CELL
Xcell_20_28 row_20_28 row_20_29 col_20_28 col_21_28 gap_20_28 CELL
Xcell_20_29 row_20_29 row_20_30 col_20_29 col_21_29 gap_20_29 CELL
Xcell_20_30 row_20_30 row_20_31 col_20_30 col_21_30 gap_20_30 CELL
Xcell_20_31 row_20_31 row_20_32 col_20_31 col_21_31 gap_20_31 CELL
Xcell_21_0 row_21_0 row_21_1 col_21_0 col_22_0 gap_21_0 CELL
Xcell_21_1 row_21_1 row_21_2 col_21_1 col_22_1 gap_21_1 CELL
Xcell_21_2 row_21_2 row_21_3 col_21_2 col_22_2 gap_21_2 CELL
Xcell_21_3 row_21_3 row_21_4 col_21_3 col_22_3 gap_21_3 CELL
Xcell_21_4 row_21_4 row_21_5 col_21_4 col_22_4 gap_21_4 CELL
Xcell_21_5 row_21_5 row_21_6 col_21_5 col_22_5 gap_21_5 CELL
Xcell_21_6 row_21_6 row_21_7 col_21_6 col_22_6 gap_21_6 CELL
Xcell_21_7 row_21_7 row_21_8 col_21_7 col_22_7 gap_21_7 CELL
Xcell_21_8 row_21_8 row_21_9 col_21_8 col_22_8 gap_21_8 CELL
Xcell_21_9 row_21_9 row_21_10 col_21_9 col_22_9 gap_21_9 CELL
Xcell_21_10 row_21_10 row_21_11 col_21_10 col_22_10 gap_21_10 CELL
Xcell_21_11 row_21_11 row_21_12 col_21_11 col_22_11 gap_21_11 CELL
Xcell_21_12 row_21_12 row_21_13 col_21_12 col_22_12 gap_21_12 CELL
Xcell_21_13 row_21_13 row_21_14 col_21_13 col_22_13 gap_21_13 CELL
Xcell_21_14 row_21_14 row_21_15 col_21_14 col_22_14 gap_21_14 CELL
Xcell_21_15 row_21_15 row_21_16 col_21_15 col_22_15 gap_21_15 CELL
Xcell_21_16 row_21_16 row_21_17 col_21_16 col_22_16 gap_21_16 CELL
Xcell_21_17 row_21_17 row_21_18 col_21_17 col_22_17 gap_21_17 CELL
Xcell_21_18 row_21_18 row_21_19 col_21_18 col_22_18 gap_21_18 CELL
Xcell_21_19 row_21_19 row_21_20 col_21_19 col_22_19 gap_21_19 CELL
Xcell_21_20 row_21_20 row_21_21 col_21_20 col_22_20 gap_21_20 CELL
Xcell_21_21 row_21_21 row_21_22 col_21_21 col_22_21 gap_21_21 CELL
Xcell_21_22 row_21_22 row_21_23 col_21_22 col_22_22 gap_21_22 CELL
Xcell_21_23 row_21_23 row_21_24 col_21_23 col_22_23 gap_21_23 CELL
Xcell_21_24 row_21_24 row_21_25 col_21_24 col_22_24 gap_21_24 CELL
Xcell_21_25 row_21_25 row_21_26 col_21_25 col_22_25 gap_21_25 CELL
Xcell_21_26 row_21_26 row_21_27 col_21_26 col_22_26 gap_21_26 CELL
Xcell_21_27 row_21_27 row_21_28 col_21_27 col_22_27 gap_21_27 CELL
Xcell_21_28 row_21_28 row_21_29 col_21_28 col_22_28 gap_21_28 CELL
Xcell_21_29 row_21_29 row_21_30 col_21_29 col_22_29 gap_21_29 CELL
Xcell_21_30 row_21_30 row_21_31 col_21_30 col_22_30 gap_21_30 CELL
Xcell_21_31 row_21_31 row_21_32 col_21_31 col_22_31 gap_21_31 CELL
Xcell_22_0 row_22_0 row_22_1 col_22_0 col_23_0 gap_22_0 CELL
Xcell_22_1 row_22_1 row_22_2 col_22_1 col_23_1 gap_22_1 CELL
Xcell_22_2 row_22_2 row_22_3 col_22_2 col_23_2 gap_22_2 CELL
Xcell_22_3 row_22_3 row_22_4 col_22_3 col_23_3 gap_22_3 CELL
Xcell_22_4 row_22_4 row_22_5 col_22_4 col_23_4 gap_22_4 CELL
Xcell_22_5 row_22_5 row_22_6 col_22_5 col_23_5 gap_22_5 CELL
Xcell_22_6 row_22_6 row_22_7 col_22_6 col_23_6 gap_22_6 CELL
Xcell_22_7 row_22_7 row_22_8 col_22_7 col_23_7 gap_22_7 CELL
Xcell_22_8 row_22_8 row_22_9 col_22_8 col_23_8 gap_22_8 CELL
Xcell_22_9 row_22_9 row_22_10 col_22_9 col_23_9 gap_22_9 CELL
Xcell_22_10 row_22_10 row_22_11 col_22_10 col_23_10 gap_22_10 CELL
Xcell_22_11 row_22_11 row_22_12 col_22_11 col_23_11 gap_22_11 CELL
Xcell_22_12 row_22_12 row_22_13 col_22_12 col_23_12 gap_22_12 CELL
Xcell_22_13 row_22_13 row_22_14 col_22_13 col_23_13 gap_22_13 CELL
Xcell_22_14 row_22_14 row_22_15 col_22_14 col_23_14 gap_22_14 CELL
Xcell_22_15 row_22_15 row_22_16 col_22_15 col_23_15 gap_22_15 CELL
Xcell_22_16 row_22_16 row_22_17 col_22_16 col_23_16 gap_22_16 CELL
Xcell_22_17 row_22_17 row_22_18 col_22_17 col_23_17 gap_22_17 CELL
Xcell_22_18 row_22_18 row_22_19 col_22_18 col_23_18 gap_22_18 CELL
Xcell_22_19 row_22_19 row_22_20 col_22_19 col_23_19 gap_22_19 CELL
Xcell_22_20 row_22_20 row_22_21 col_22_20 col_23_20 gap_22_20 CELL
Xcell_22_21 row_22_21 row_22_22 col_22_21 col_23_21 gap_22_21 CELL
Xcell_22_22 row_22_22 row_22_23 col_22_22 col_23_22 gap_22_22 CELL
Xcell_22_23 row_22_23 row_22_24 col_22_23 col_23_23 gap_22_23 CELL
Xcell_22_24 row_22_24 row_22_25 col_22_24 col_23_24 gap_22_24 CELL
Xcell_22_25 row_22_25 row_22_26 col_22_25 col_23_25 gap_22_25 CELL
Xcell_22_26 row_22_26 row_22_27 col_22_26 col_23_26 gap_22_26 CELL
Xcell_22_27 row_22_27 row_22_28 col_22_27 col_23_27 gap_22_27 CELL
Xcell_22_28 row_22_28 row_22_29 col_22_28 col_23_28 gap_22_28 CELL
Xcell_22_29 row_22_29 row_22_30 col_22_29 col_23_29 gap_22_29 CELL
Xcell_22_30 row_22_30 row_22_31 col_22_30 col_23_30 gap_22_30 CELL
Xcell_22_31 row_22_31 row_22_32 col_22_31 col_23_31 gap_22_31 CELL
Xcell_23_0 row_23_0 row_23_1 col_23_0 col_24_0 gap_23_0 CELL
Xcell_23_1 row_23_1 row_23_2 col_23_1 col_24_1 gap_23_1 CELL
Xcell_23_2 row_23_2 row_23_3 col_23_2 col_24_2 gap_23_2 CELL
Xcell_23_3 row_23_3 row_23_4 col_23_3 col_24_3 gap_23_3 CELL
Xcell_23_4 row_23_4 row_23_5 col_23_4 col_24_4 gap_23_4 CELL
Xcell_23_5 row_23_5 row_23_6 col_23_5 col_24_5 gap_23_5 CELL
Xcell_23_6 row_23_6 row_23_7 col_23_6 col_24_6 gap_23_6 CELL
Xcell_23_7 row_23_7 row_23_8 col_23_7 col_24_7 gap_23_7 CELL
Xcell_23_8 row_23_8 row_23_9 col_23_8 col_24_8 gap_23_8 CELL
Xcell_23_9 row_23_9 row_23_10 col_23_9 col_24_9 gap_23_9 CELL
Xcell_23_10 row_23_10 row_23_11 col_23_10 col_24_10 gap_23_10 CELL
Xcell_23_11 row_23_11 row_23_12 col_23_11 col_24_11 gap_23_11 CELL
Xcell_23_12 row_23_12 row_23_13 col_23_12 col_24_12 gap_23_12 CELL
Xcell_23_13 row_23_13 row_23_14 col_23_13 col_24_13 gap_23_13 CELL
Xcell_23_14 row_23_14 row_23_15 col_23_14 col_24_14 gap_23_14 CELL
Xcell_23_15 row_23_15 row_23_16 col_23_15 col_24_15 gap_23_15 CELL
Xcell_23_16 row_23_16 row_23_17 col_23_16 col_24_16 gap_23_16 CELL
Xcell_23_17 row_23_17 row_23_18 col_23_17 col_24_17 gap_23_17 CELL
Xcell_23_18 row_23_18 row_23_19 col_23_18 col_24_18 gap_23_18 CELL
Xcell_23_19 row_23_19 row_23_20 col_23_19 col_24_19 gap_23_19 CELL
Xcell_23_20 row_23_20 row_23_21 col_23_20 col_24_20 gap_23_20 CELL
Xcell_23_21 row_23_21 row_23_22 col_23_21 col_24_21 gap_23_21 CELL
Xcell_23_22 row_23_22 row_23_23 col_23_22 col_24_22 gap_23_22 CELL
Xcell_23_23 row_23_23 row_23_24 col_23_23 col_24_23 gap_23_23 CELL
Xcell_23_24 row_23_24 row_23_25 col_23_24 col_24_24 gap_23_24 CELL
Xcell_23_25 row_23_25 row_23_26 col_23_25 col_24_25 gap_23_25 CELL
Xcell_23_26 row_23_26 row_23_27 col_23_26 col_24_26 gap_23_26 CELL
Xcell_23_27 row_23_27 row_23_28 col_23_27 col_24_27 gap_23_27 CELL
Xcell_23_28 row_23_28 row_23_29 col_23_28 col_24_28 gap_23_28 CELL
Xcell_23_29 row_23_29 row_23_30 col_23_29 col_24_29 gap_23_29 CELL
Xcell_23_30 row_23_30 row_23_31 col_23_30 col_24_30 gap_23_30 CELL
Xcell_23_31 row_23_31 row_23_32 col_23_31 col_24_31 gap_23_31 CELL
Xcell_24_0 row_24_0 row_24_1 col_24_0 col_25_0 gap_24_0 CELL
Xcell_24_1 row_24_1 row_24_2 col_24_1 col_25_1 gap_24_1 CELL
Xcell_24_2 row_24_2 row_24_3 col_24_2 col_25_2 gap_24_2 CELL
Xcell_24_3 row_24_3 row_24_4 col_24_3 col_25_3 gap_24_3 CELL
Xcell_24_4 row_24_4 row_24_5 col_24_4 col_25_4 gap_24_4 CELL
Xcell_24_5 row_24_5 row_24_6 col_24_5 col_25_5 gap_24_5 CELL
Xcell_24_6 row_24_6 row_24_7 col_24_6 col_25_6 gap_24_6 CELL
Xcell_24_7 row_24_7 row_24_8 col_24_7 col_25_7 gap_24_7 CELL
Xcell_24_8 row_24_8 row_24_9 col_24_8 col_25_8 gap_24_8 CELL
Xcell_24_9 row_24_9 row_24_10 col_24_9 col_25_9 gap_24_9 CELL
Xcell_24_10 row_24_10 row_24_11 col_24_10 col_25_10 gap_24_10 CELL
Xcell_24_11 row_24_11 row_24_12 col_24_11 col_25_11 gap_24_11 CELL
Xcell_24_12 row_24_12 row_24_13 col_24_12 col_25_12 gap_24_12 CELL
Xcell_24_13 row_24_13 row_24_14 col_24_13 col_25_13 gap_24_13 CELL
Xcell_24_14 row_24_14 row_24_15 col_24_14 col_25_14 gap_24_14 CELL
Xcell_24_15 row_24_15 row_24_16 col_24_15 col_25_15 gap_24_15 CELL
Xcell_24_16 row_24_16 row_24_17 col_24_16 col_25_16 gap_24_16 CELL
Xcell_24_17 row_24_17 row_24_18 col_24_17 col_25_17 gap_24_17 CELL
Xcell_24_18 row_24_18 row_24_19 col_24_18 col_25_18 gap_24_18 CELL
Xcell_24_19 row_24_19 row_24_20 col_24_19 col_25_19 gap_24_19 CELL
Xcell_24_20 row_24_20 row_24_21 col_24_20 col_25_20 gap_24_20 CELL
Xcell_24_21 row_24_21 row_24_22 col_24_21 col_25_21 gap_24_21 CELL
Xcell_24_22 row_24_22 row_24_23 col_24_22 col_25_22 gap_24_22 CELL
Xcell_24_23 row_24_23 row_24_24 col_24_23 col_25_23 gap_24_23 CELL
Xcell_24_24 row_24_24 row_24_25 col_24_24 col_25_24 gap_24_24 CELL
Xcell_24_25 row_24_25 row_24_26 col_24_25 col_25_25 gap_24_25 CELL
Xcell_24_26 row_24_26 row_24_27 col_24_26 col_25_26 gap_24_26 CELL
Xcell_24_27 row_24_27 row_24_28 col_24_27 col_25_27 gap_24_27 CELL
Xcell_24_28 row_24_28 row_24_29 col_24_28 col_25_28 gap_24_28 CELL
Xcell_24_29 row_24_29 row_24_30 col_24_29 col_25_29 gap_24_29 CELL
Xcell_24_30 row_24_30 row_24_31 col_24_30 col_25_30 gap_24_30 CELL
Xcell_24_31 row_24_31 row_24_32 col_24_31 col_25_31 gap_24_31 CELL
Xcell_25_0 row_25_0 row_25_1 col_25_0 col_26_0 gap_25_0 CELL
Xcell_25_1 row_25_1 row_25_2 col_25_1 col_26_1 gap_25_1 CELL
Xcell_25_2 row_25_2 row_25_3 col_25_2 col_26_2 gap_25_2 CELL
Xcell_25_3 row_25_3 row_25_4 col_25_3 col_26_3 gap_25_3 CELL
Xcell_25_4 row_25_4 row_25_5 col_25_4 col_26_4 gap_25_4 CELL
Xcell_25_5 row_25_5 row_25_6 col_25_5 col_26_5 gap_25_5 CELL
Xcell_25_6 row_25_6 row_25_7 col_25_6 col_26_6 gap_25_6 CELL
Xcell_25_7 row_25_7 row_25_8 col_25_7 col_26_7 gap_25_7 CELL
Xcell_25_8 row_25_8 row_25_9 col_25_8 col_26_8 gap_25_8 CELL
Xcell_25_9 row_25_9 row_25_10 col_25_9 col_26_9 gap_25_9 CELL
Xcell_25_10 row_25_10 row_25_11 col_25_10 col_26_10 gap_25_10 CELL
Xcell_25_11 row_25_11 row_25_12 col_25_11 col_26_11 gap_25_11 CELL
Xcell_25_12 row_25_12 row_25_13 col_25_12 col_26_12 gap_25_12 CELL
Xcell_25_13 row_25_13 row_25_14 col_25_13 col_26_13 gap_25_13 CELL
Xcell_25_14 row_25_14 row_25_15 col_25_14 col_26_14 gap_25_14 CELL
Xcell_25_15 row_25_15 row_25_16 col_25_15 col_26_15 gap_25_15 CELL
Xcell_25_16 row_25_16 row_25_17 col_25_16 col_26_16 gap_25_16 CELL
Xcell_25_17 row_25_17 row_25_18 col_25_17 col_26_17 gap_25_17 CELL
Xcell_25_18 row_25_18 row_25_19 col_25_18 col_26_18 gap_25_18 CELL
Xcell_25_19 row_25_19 row_25_20 col_25_19 col_26_19 gap_25_19 CELL
Xcell_25_20 row_25_20 row_25_21 col_25_20 col_26_20 gap_25_20 CELL
Xcell_25_21 row_25_21 row_25_22 col_25_21 col_26_21 gap_25_21 CELL
Xcell_25_22 row_25_22 row_25_23 col_25_22 col_26_22 gap_25_22 CELL
Xcell_25_23 row_25_23 row_25_24 col_25_23 col_26_23 gap_25_23 CELL
Xcell_25_24 row_25_24 row_25_25 col_25_24 col_26_24 gap_25_24 CELL
Xcell_25_25 row_25_25 row_25_26 col_25_25 col_26_25 gap_25_25 CELL
Xcell_25_26 row_25_26 row_25_27 col_25_26 col_26_26 gap_25_26 CELL
Xcell_25_27 row_25_27 row_25_28 col_25_27 col_26_27 gap_25_27 CELL
Xcell_25_28 row_25_28 row_25_29 col_25_28 col_26_28 gap_25_28 CELL
Xcell_25_29 row_25_29 row_25_30 col_25_29 col_26_29 gap_25_29 CELL
Xcell_25_30 row_25_30 row_25_31 col_25_30 col_26_30 gap_25_30 CELL
Xcell_25_31 row_25_31 row_25_32 col_25_31 col_26_31 gap_25_31 CELL
Xcell_26_0 row_26_0 row_26_1 col_26_0 col_27_0 gap_26_0 CELL
Xcell_26_1 row_26_1 row_26_2 col_26_1 col_27_1 gap_26_1 CELL
Xcell_26_2 row_26_2 row_26_3 col_26_2 col_27_2 gap_26_2 CELL
Xcell_26_3 row_26_3 row_26_4 col_26_3 col_27_3 gap_26_3 CELL
Xcell_26_4 row_26_4 row_26_5 col_26_4 col_27_4 gap_26_4 CELL
Xcell_26_5 row_26_5 row_26_6 col_26_5 col_27_5 gap_26_5 CELL
Xcell_26_6 row_26_6 row_26_7 col_26_6 col_27_6 gap_26_6 CELL
Xcell_26_7 row_26_7 row_26_8 col_26_7 col_27_7 gap_26_7 CELL
Xcell_26_8 row_26_8 row_26_9 col_26_8 col_27_8 gap_26_8 CELL
Xcell_26_9 row_26_9 row_26_10 col_26_9 col_27_9 gap_26_9 CELL
Xcell_26_10 row_26_10 row_26_11 col_26_10 col_27_10 gap_26_10 CELL
Xcell_26_11 row_26_11 row_26_12 col_26_11 col_27_11 gap_26_11 CELL
Xcell_26_12 row_26_12 row_26_13 col_26_12 col_27_12 gap_26_12 CELL
Xcell_26_13 row_26_13 row_26_14 col_26_13 col_27_13 gap_26_13 CELL
Xcell_26_14 row_26_14 row_26_15 col_26_14 col_27_14 gap_26_14 CELL
Xcell_26_15 row_26_15 row_26_16 col_26_15 col_27_15 gap_26_15 CELL
Xcell_26_16 row_26_16 row_26_17 col_26_16 col_27_16 gap_26_16 CELL
Xcell_26_17 row_26_17 row_26_18 col_26_17 col_27_17 gap_26_17 CELL
Xcell_26_18 row_26_18 row_26_19 col_26_18 col_27_18 gap_26_18 CELL
Xcell_26_19 row_26_19 row_26_20 col_26_19 col_27_19 gap_26_19 CELL
Xcell_26_20 row_26_20 row_26_21 col_26_20 col_27_20 gap_26_20 CELL
Xcell_26_21 row_26_21 row_26_22 col_26_21 col_27_21 gap_26_21 CELL
Xcell_26_22 row_26_22 row_26_23 col_26_22 col_27_22 gap_26_22 CELL
Xcell_26_23 row_26_23 row_26_24 col_26_23 col_27_23 gap_26_23 CELL
Xcell_26_24 row_26_24 row_26_25 col_26_24 col_27_24 gap_26_24 CELL
Xcell_26_25 row_26_25 row_26_26 col_26_25 col_27_25 gap_26_25 CELL
Xcell_26_26 row_26_26 row_26_27 col_26_26 col_27_26 gap_26_26 CELL
Xcell_26_27 row_26_27 row_26_28 col_26_27 col_27_27 gap_26_27 CELL
Xcell_26_28 row_26_28 row_26_29 col_26_28 col_27_28 gap_26_28 CELL
Xcell_26_29 row_26_29 row_26_30 col_26_29 col_27_29 gap_26_29 CELL
Xcell_26_30 row_26_30 row_26_31 col_26_30 col_27_30 gap_26_30 CELL
Xcell_26_31 row_26_31 row_26_32 col_26_31 col_27_31 gap_26_31 CELL
Xcell_27_0 row_27_0 row_27_1 col_27_0 col_28_0 gap_27_0 CELL
Xcell_27_1 row_27_1 row_27_2 col_27_1 col_28_1 gap_27_1 CELL
Xcell_27_2 row_27_2 row_27_3 col_27_2 col_28_2 gap_27_2 CELL
Xcell_27_3 row_27_3 row_27_4 col_27_3 col_28_3 gap_27_3 CELL
Xcell_27_4 row_27_4 row_27_5 col_27_4 col_28_4 gap_27_4 CELL
Xcell_27_5 row_27_5 row_27_6 col_27_5 col_28_5 gap_27_5 CELL
Xcell_27_6 row_27_6 row_27_7 col_27_6 col_28_6 gap_27_6 CELL
Xcell_27_7 row_27_7 row_27_8 col_27_7 col_28_7 gap_27_7 CELL
Xcell_27_8 row_27_8 row_27_9 col_27_8 col_28_8 gap_27_8 CELL
Xcell_27_9 row_27_9 row_27_10 col_27_9 col_28_9 gap_27_9 CELL
Xcell_27_10 row_27_10 row_27_11 col_27_10 col_28_10 gap_27_10 CELL
Xcell_27_11 row_27_11 row_27_12 col_27_11 col_28_11 gap_27_11 CELL
Xcell_27_12 row_27_12 row_27_13 col_27_12 col_28_12 gap_27_12 CELL
Xcell_27_13 row_27_13 row_27_14 col_27_13 col_28_13 gap_27_13 CELL
Xcell_27_14 row_27_14 row_27_15 col_27_14 col_28_14 gap_27_14 CELL
Xcell_27_15 row_27_15 row_27_16 col_27_15 col_28_15 gap_27_15 CELL
Xcell_27_16 row_27_16 row_27_17 col_27_16 col_28_16 gap_27_16 CELL
Xcell_27_17 row_27_17 row_27_18 col_27_17 col_28_17 gap_27_17 CELL
Xcell_27_18 row_27_18 row_27_19 col_27_18 col_28_18 gap_27_18 CELL
Xcell_27_19 row_27_19 row_27_20 col_27_19 col_28_19 gap_27_19 CELL
Xcell_27_20 row_27_20 row_27_21 col_27_20 col_28_20 gap_27_20 CELL
Xcell_27_21 row_27_21 row_27_22 col_27_21 col_28_21 gap_27_21 CELL
Xcell_27_22 row_27_22 row_27_23 col_27_22 col_28_22 gap_27_22 CELL
Xcell_27_23 row_27_23 row_27_24 col_27_23 col_28_23 gap_27_23 CELL
Xcell_27_24 row_27_24 row_27_25 col_27_24 col_28_24 gap_27_24 CELL
Xcell_27_25 row_27_25 row_27_26 col_27_25 col_28_25 gap_27_25 CELL
Xcell_27_26 row_27_26 row_27_27 col_27_26 col_28_26 gap_27_26 CELL
Xcell_27_27 row_27_27 row_27_28 col_27_27 col_28_27 gap_27_27 CELL
Xcell_27_28 row_27_28 row_27_29 col_27_28 col_28_28 gap_27_28 CELL
Xcell_27_29 row_27_29 row_27_30 col_27_29 col_28_29 gap_27_29 CELL
Xcell_27_30 row_27_30 row_27_31 col_27_30 col_28_30 gap_27_30 CELL
Xcell_27_31 row_27_31 row_27_32 col_27_31 col_28_31 gap_27_31 CELL
Xcell_28_0 row_28_0 row_28_1 col_28_0 col_29_0 gap_28_0 CELL
Xcell_28_1 row_28_1 row_28_2 col_28_1 col_29_1 gap_28_1 CELL
Xcell_28_2 row_28_2 row_28_3 col_28_2 col_29_2 gap_28_2 CELL
Xcell_28_3 row_28_3 row_28_4 col_28_3 col_29_3 gap_28_3 CELL
Xcell_28_4 row_28_4 row_28_5 col_28_4 col_29_4 gap_28_4 CELL
Xcell_28_5 row_28_5 row_28_6 col_28_5 col_29_5 gap_28_5 CELL
Xcell_28_6 row_28_6 row_28_7 col_28_6 col_29_6 gap_28_6 CELL
Xcell_28_7 row_28_7 row_28_8 col_28_7 col_29_7 gap_28_7 CELL
Xcell_28_8 row_28_8 row_28_9 col_28_8 col_29_8 gap_28_8 CELL
Xcell_28_9 row_28_9 row_28_10 col_28_9 col_29_9 gap_28_9 CELL
Xcell_28_10 row_28_10 row_28_11 col_28_10 col_29_10 gap_28_10 CELL
Xcell_28_11 row_28_11 row_28_12 col_28_11 col_29_11 gap_28_11 CELL
Xcell_28_12 row_28_12 row_28_13 col_28_12 col_29_12 gap_28_12 CELL
Xcell_28_13 row_28_13 row_28_14 col_28_13 col_29_13 gap_28_13 CELL
Xcell_28_14 row_28_14 row_28_15 col_28_14 col_29_14 gap_28_14 CELL
Xcell_28_15 row_28_15 row_28_16 col_28_15 col_29_15 gap_28_15 CELL
Xcell_28_16 row_28_16 row_28_17 col_28_16 col_29_16 gap_28_16 CELL
Xcell_28_17 row_28_17 row_28_18 col_28_17 col_29_17 gap_28_17 CELL
Xcell_28_18 row_28_18 row_28_19 col_28_18 col_29_18 gap_28_18 CELL
Xcell_28_19 row_28_19 row_28_20 col_28_19 col_29_19 gap_28_19 CELL
Xcell_28_20 row_28_20 row_28_21 col_28_20 col_29_20 gap_28_20 CELL
Xcell_28_21 row_28_21 row_28_22 col_28_21 col_29_21 gap_28_21 CELL
Xcell_28_22 row_28_22 row_28_23 col_28_22 col_29_22 gap_28_22 CELL
Xcell_28_23 row_28_23 row_28_24 col_28_23 col_29_23 gap_28_23 CELL
Xcell_28_24 row_28_24 row_28_25 col_28_24 col_29_24 gap_28_24 CELL
Xcell_28_25 row_28_25 row_28_26 col_28_25 col_29_25 gap_28_25 CELL
Xcell_28_26 row_28_26 row_28_27 col_28_26 col_29_26 gap_28_26 CELL
Xcell_28_27 row_28_27 row_28_28 col_28_27 col_29_27 gap_28_27 CELL
Xcell_28_28 row_28_28 row_28_29 col_28_28 col_29_28 gap_28_28 CELL
Xcell_28_29 row_28_29 row_28_30 col_28_29 col_29_29 gap_28_29 CELL
Xcell_28_30 row_28_30 row_28_31 col_28_30 col_29_30 gap_28_30 CELL
Xcell_28_31 row_28_31 row_28_32 col_28_31 col_29_31 gap_28_31 CELL
Xcell_29_0 row_29_0 row_29_1 col_29_0 col_30_0 gap_29_0 CELL
Xcell_29_1 row_29_1 row_29_2 col_29_1 col_30_1 gap_29_1 CELL
Xcell_29_2 row_29_2 row_29_3 col_29_2 col_30_2 gap_29_2 CELL
Xcell_29_3 row_29_3 row_29_4 col_29_3 col_30_3 gap_29_3 CELL
Xcell_29_4 row_29_4 row_29_5 col_29_4 col_30_4 gap_29_4 CELL
Xcell_29_5 row_29_5 row_29_6 col_29_5 col_30_5 gap_29_5 CELL
Xcell_29_6 row_29_6 row_29_7 col_29_6 col_30_6 gap_29_6 CELL
Xcell_29_7 row_29_7 row_29_8 col_29_7 col_30_7 gap_29_7 CELL
Xcell_29_8 row_29_8 row_29_9 col_29_8 col_30_8 gap_29_8 CELL
Xcell_29_9 row_29_9 row_29_10 col_29_9 col_30_9 gap_29_9 CELL
Xcell_29_10 row_29_10 row_29_11 col_29_10 col_30_10 gap_29_10 CELL
Xcell_29_11 row_29_11 row_29_12 col_29_11 col_30_11 gap_29_11 CELL
Xcell_29_12 row_29_12 row_29_13 col_29_12 col_30_12 gap_29_12 CELL
Xcell_29_13 row_29_13 row_29_14 col_29_13 col_30_13 gap_29_13 CELL
Xcell_29_14 row_29_14 row_29_15 col_29_14 col_30_14 gap_29_14 CELL
Xcell_29_15 row_29_15 row_29_16 col_29_15 col_30_15 gap_29_15 CELL
Xcell_29_16 row_29_16 row_29_17 col_29_16 col_30_16 gap_29_16 CELL
Xcell_29_17 row_29_17 row_29_18 col_29_17 col_30_17 gap_29_17 CELL
Xcell_29_18 row_29_18 row_29_19 col_29_18 col_30_18 gap_29_18 CELL
Xcell_29_19 row_29_19 row_29_20 col_29_19 col_30_19 gap_29_19 CELL
Xcell_29_20 row_29_20 row_29_21 col_29_20 col_30_20 gap_29_20 CELL
Xcell_29_21 row_29_21 row_29_22 col_29_21 col_30_21 gap_29_21 CELL
Xcell_29_22 row_29_22 row_29_23 col_29_22 col_30_22 gap_29_22 CELL
Xcell_29_23 row_29_23 row_29_24 col_29_23 col_30_23 gap_29_23 CELL
Xcell_29_24 row_29_24 row_29_25 col_29_24 col_30_24 gap_29_24 CELL
Xcell_29_25 row_29_25 row_29_26 col_29_25 col_30_25 gap_29_25 CELL
Xcell_29_26 row_29_26 row_29_27 col_29_26 col_30_26 gap_29_26 CELL
Xcell_29_27 row_29_27 row_29_28 col_29_27 col_30_27 gap_29_27 CELL
Xcell_29_28 row_29_28 row_29_29 col_29_28 col_30_28 gap_29_28 CELL
Xcell_29_29 row_29_29 row_29_30 col_29_29 col_30_29 gap_29_29 CELL
Xcell_29_30 row_29_30 row_29_31 col_29_30 col_30_30 gap_29_30 CELL
Xcell_29_31 row_29_31 row_29_32 col_29_31 col_30_31 gap_29_31 CELL
Xcell_30_0 row_30_0 row_30_1 col_30_0 col_31_0 gap_30_0 CELL
Xcell_30_1 row_30_1 row_30_2 col_30_1 col_31_1 gap_30_1 CELL
Xcell_30_2 row_30_2 row_30_3 col_30_2 col_31_2 gap_30_2 CELL
Xcell_30_3 row_30_3 row_30_4 col_30_3 col_31_3 gap_30_3 CELL
Xcell_30_4 row_30_4 row_30_5 col_30_4 col_31_4 gap_30_4 CELL
Xcell_30_5 row_30_5 row_30_6 col_30_5 col_31_5 gap_30_5 CELL
Xcell_30_6 row_30_6 row_30_7 col_30_6 col_31_6 gap_30_6 CELL
Xcell_30_7 row_30_7 row_30_8 col_30_7 col_31_7 gap_30_7 CELL
Xcell_30_8 row_30_8 row_30_9 col_30_8 col_31_8 gap_30_8 CELL
Xcell_30_9 row_30_9 row_30_10 col_30_9 col_31_9 gap_30_9 CELL
Xcell_30_10 row_30_10 row_30_11 col_30_10 col_31_10 gap_30_10 CELL
Xcell_30_11 row_30_11 row_30_12 col_30_11 col_31_11 gap_30_11 CELL
Xcell_30_12 row_30_12 row_30_13 col_30_12 col_31_12 gap_30_12 CELL
Xcell_30_13 row_30_13 row_30_14 col_30_13 col_31_13 gap_30_13 CELL
Xcell_30_14 row_30_14 row_30_15 col_30_14 col_31_14 gap_30_14 CELL
Xcell_30_15 row_30_15 row_30_16 col_30_15 col_31_15 gap_30_15 CELL
Xcell_30_16 row_30_16 row_30_17 col_30_16 col_31_16 gap_30_16 CELL
Xcell_30_17 row_30_17 row_30_18 col_30_17 col_31_17 gap_30_17 CELL
Xcell_30_18 row_30_18 row_30_19 col_30_18 col_31_18 gap_30_18 CELL
Xcell_30_19 row_30_19 row_30_20 col_30_19 col_31_19 gap_30_19 CELL
Xcell_30_20 row_30_20 row_30_21 col_30_20 col_31_20 gap_30_20 CELL
Xcell_30_21 row_30_21 row_30_22 col_30_21 col_31_21 gap_30_21 CELL
Xcell_30_22 row_30_22 row_30_23 col_30_22 col_31_22 gap_30_22 CELL
Xcell_30_23 row_30_23 row_30_24 col_30_23 col_31_23 gap_30_23 CELL
Xcell_30_24 row_30_24 row_30_25 col_30_24 col_31_24 gap_30_24 CELL
Xcell_30_25 row_30_25 row_30_26 col_30_25 col_31_25 gap_30_25 CELL
Xcell_30_26 row_30_26 row_30_27 col_30_26 col_31_26 gap_30_26 CELL
Xcell_30_27 row_30_27 row_30_28 col_30_27 col_31_27 gap_30_27 CELL
Xcell_30_28 row_30_28 row_30_29 col_30_28 col_31_28 gap_30_28 CELL
Xcell_30_29 row_30_29 row_30_30 col_30_29 col_31_29 gap_30_29 CELL
Xcell_30_30 row_30_30 row_30_31 col_30_30 col_31_30 gap_30_30 CELL
Xcell_30_31 row_30_31 row_30_32 col_30_31 col_31_31 gap_30_31 CELL
Xcell_31_0 row_31_0 row_31_1 col_31_0 col_32_0 gap_31_0 CELL
Xcell_31_1 row_31_1 row_31_2 col_31_1 col_32_1 gap_31_1 CELL
Xcell_31_2 row_31_2 row_31_3 col_31_2 col_32_2 gap_31_2 CELL
Xcell_31_3 row_31_3 row_31_4 col_31_3 col_32_3 gap_31_3 CELL
Xcell_31_4 row_31_4 row_31_5 col_31_4 col_32_4 gap_31_4 CELL
Xcell_31_5 row_31_5 row_31_6 col_31_5 col_32_5 gap_31_5 CELL
Xcell_31_6 row_31_6 row_31_7 col_31_6 col_32_6 gap_31_6 CELL
Xcell_31_7 row_31_7 row_31_8 col_31_7 col_32_7 gap_31_7 CELL
Xcell_31_8 row_31_8 row_31_9 col_31_8 col_32_8 gap_31_8 CELL
Xcell_31_9 row_31_9 row_31_10 col_31_9 col_32_9 gap_31_9 CELL
Xcell_31_10 row_31_10 row_31_11 col_31_10 col_32_10 gap_31_10 CELL
Xcell_31_11 row_31_11 row_31_12 col_31_11 col_32_11 gap_31_11 CELL
Xcell_31_12 row_31_12 row_31_13 col_31_12 col_32_12 gap_31_12 CELL
Xcell_31_13 row_31_13 row_31_14 col_31_13 col_32_13 gap_31_13 CELL
Xcell_31_14 row_31_14 row_31_15 col_31_14 col_32_14 gap_31_14 CELL
Xcell_31_15 row_31_15 row_31_16 col_31_15 col_32_15 gap_31_15 CELL
Xcell_31_16 row_31_16 row_31_17 col_31_16 col_32_16 gap_31_16 CELL
Xcell_31_17 row_31_17 row_31_18 col_31_17 col_32_17 gap_31_17 CELL
Xcell_31_18 row_31_18 row_31_19 col_31_18 col_32_18 gap_31_18 CELL
Xcell_31_19 row_31_19 row_31_20 col_31_19 col_32_19 gap_31_19 CELL
Xcell_31_20 row_31_20 row_31_21 col_31_20 col_32_20 gap_31_20 CELL
Xcell_31_21 row_31_21 row_31_22 col_31_21 col_32_21 gap_31_21 CELL
Xcell_31_22 row_31_22 row_31_23 col_31_22 col_32_22 gap_31_22 CELL
Xcell_31_23 row_31_23 row_31_24 col_31_23 col_32_23 gap_31_23 CELL
Xcell_31_24 row_31_24 row_31_25 col_31_24 col_32_24 gap_31_24 CELL
Xcell_31_25 row_31_25 row_31_26 col_31_25 col_32_25 gap_31_25 CELL
Xcell_31_26 row_31_26 row_31_27 col_31_26 col_32_26 gap_31_26 CELL
Xcell_31_27 row_31_27 row_31_28 col_31_27 col_32_27 gap_31_27 CELL
Xcell_31_28 row_31_28 row_31_29 col_31_28 col_32_28 gap_31_28 CELL
Xcell_31_29 row_31_29 row_31_30 col_31_29 col_32_29 gap_31_29 CELL
Xcell_31_30 row_31_30 row_31_31 col_31_30 col_32_30 gap_31_30 CELL
Xcell_31_31 row_31_31 row_31_32 col_31_31 col_32_31 gap_31_31 CELL

** PWL voltage waveforms **
Vrow_0 row_0_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.2            2.9e-06 0.2          3e-06 0              3.9e-06 0            4e-06 0.2            4.9e-06 0.2          5e-06 0              5.9e-06 0            6e-06 0.2            6.9e-06 0.2          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.2            2.09e-05 0.2         2.1e-05 0            2.19e-05 0           2.2e-05 0.2          2.29e-05 0.2         2.3e-05 0            2.39e-05 0           2.4e-05 0.2          2.49e-05 0.2         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 1.5          8.29e-05 1.5         8.3e-05 0            8.39e-05 0           8.4e-05 0            8.49e-05 0           8.5e-05 0            8.59e-05 0           8.6e-05 1.5          8.69e-05 1.5         8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0             0.0001009 0          0.000101 0           0.0001019 0          0.000102 1.5         0.0001029 1.5        0.000103 0           0.0001039 0          0.000104 0           0.0001049 0          0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.2         0.0001629 0.2        0.000163 0           0.0001639 0          0.000164 0.2         0.0001649 0.2        0.000165 0           0.0001659 0          0.000166 0.2         0.0001669 0.2        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.2          0.0001809 0.2        0.000181 0           0.0001819 0          0.000182 0.2         0.0001829 0.2        0.000183 0           0.0001839 0          0.000184 0.2         0.0001849 0.2        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0           0.0002429 0          0.000243 0           0.0002439 0          0.000244 1.5         0.0002449 1.5        0.000245 0           0.0002459 0          0.000246 0           0.0002469 0          0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 1.5          0.0002609 1.5        0.000261 0           0.0002619 0          0.000262 0           0.0002629 0          0.000263 0           0.0002639 0          0.000264 1.5         0.0002649 1.5        0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.2         0.0003229 0.2        0.000323 0           0.0003239 0          0.000324 0.2         0.0003249 0.2        0.000325 0           0.0003259 0          0.000326 0.2         0.0003269 0.2        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.2          0.0003409 0.2        0.000341 0           0.0003419 0          0.000342 0.2         0.0003429 0.2        0.000343 0           0.0003439 0          0.000344 0.2         0.0003449 0.2        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_1 row_1_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.2            8.9e-06 0.2          9e-06 0              9.9e-06 0            1e-05 0.2            1.09e-05 0.2         1.1e-05 0            1.19e-05 0           1.2e-05 0.2          1.29e-05 0.2         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.2          2.69e-05 0.2         2.7e-05 0            2.79e-05 0           2.8e-05 0.2          2.89e-05 0.2         2.9e-05 0            2.99e-05 0           3e-05 0.2            3.09e-05 0.2         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0            8.89e-05 0           8.9e-05 0            8.99e-05 0           9e-05 1.5            9.09e-05 1.5         9.1e-05 0            9.19e-05 0           9.2e-05 0            9.29e-05 0           9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 1.5         0.0001069 1.5        0.000107 0           0.0001079 0          0.000108 0           0.0001089 0          0.000109 0           0.0001099 0          0.00011 1.5          0.0001109 1.5        0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.2         0.0001689 0.2        0.000169 0           0.0001699 0          0.00017 0.2          0.0001709 0.2        0.000171 0           0.0001719 0          0.000172 0.2         0.0001729 0.2        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.2         0.0001869 0.2        0.000187 0           0.0001879 0          0.000188 0.2         0.0001889 0.2        0.000189 0           0.0001899 0          0.00019 0.2          0.0001909 0.2        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 1.5         0.0002489 1.5        0.000249 0           0.0002499 0          0.00025 0            0.0002509 0          0.000251 0           0.0002519 0          0.000252 1.5         0.0002529 1.5        0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0           0.0002669 0          0.000267 0           0.0002679 0          0.000268 1.5         0.0002689 1.5        0.000269 0           0.0002699 0          0.00027 0            0.0002709 0          0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.2         0.0003289 0.2        0.000329 0           0.0003299 0          0.00033 0.2          0.0003309 0.2        0.000331 0           0.0003319 0          0.000332 0.2         0.0003329 0.2        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.2         0.0003469 0.2        0.000347 0           0.0003479 0          0.000348 0.2         0.0003489 0.2        0.000349 0           0.0003499 0          0.00035 0.2          0.0003509 0.2        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_2 row_2_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.2          1.49e-05 0.2         1.5e-05 0            1.59e-05 0           1.6e-05 0.2          1.69e-05 0.2         1.7e-05 0            1.79e-05 0           1.8e-05 0.2          1.89e-05 0.2         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.2          3.29e-05 0.2         3.3e-05 0            3.39e-05 0           3.4e-05 0.2          3.49e-05 0.2         3.5e-05 0            3.59e-05 0           3.6e-05 0.2          3.69e-05 0.2         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 1.5          9.49e-05 1.5         9.5e-05 0            9.59e-05 0           9.6e-05 0            9.69e-05 0           9.7e-05 0            9.79e-05 0           9.8e-05 1.5          9.89e-05 1.5         9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0           0.0001129 0          0.000113 0           0.0001139 0          0.000114 1.5         0.0001149 1.5        0.000115 0           0.0001159 0          0.000116 0           0.0001169 0          0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.2         0.0001749 0.2        0.000175 0           0.0001759 0          0.000176 0.2         0.0001769 0.2        0.000177 0           0.0001779 0          0.000178 0.2         0.0001789 0.2        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.2         0.0001929 0.2        0.000193 0           0.0001939 0          0.000194 0.2         0.0001949 0.2        0.000195 0           0.0001959 0          0.000196 0.2         0.0001969 0.2        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0           0.0002549 0          0.000255 0           0.0002559 0          0.000256 1.5         0.0002569 1.5        0.000257 0           0.0002579 0          0.000258 0           0.0002589 0          0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 1.5         0.0002729 1.5        0.000273 0           0.0002739 0          0.000274 0           0.0002749 0          0.000275 0           0.0002759 0          0.000276 1.5         0.0002769 1.5        0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.2         0.0003349 0.2        0.000335 0           0.0003359 0          0.000336 0.2         0.0003369 0.2        0.000337 0           0.0003379 0          0.000338 0.2         0.0003389 0.2        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.2         0.0003529 0.2        0.000353 0           0.0003539 0          0.000354 0.2         0.0003549 0.2        0.000355 0           0.0003559 0          0.000356 0.2         0.0003569 0.2        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_3 row_3_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_4 row_4_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_5 row_5_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_6 row_6_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_7 row_7_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_8 row_8_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_9 row_9_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_10 row_10_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_11 row_11_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_12 row_12_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_13 row_13_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_14 row_14_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_15 row_15_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.2          3.89e-05 0.2         3.9e-05 0            3.99e-05 0           4e-05 0.2            4.09e-05 0.2         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 1.5         0.0001189 1.5        0.000119 0           0.0001199 0          0.00012 0            0.0001209 0          0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.2         0.0001989 0.2        0.000199 0           0.0001999 0          0.0002 0.2           0.0002009 0.2        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0           0.0002789 0          0.000279 0           0.0002799 0          0.00028 1.5          0.0002809 1.5        0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.2         0.0003589 0.2        0.000359 0           0.0003599 0          0.00036 0.2          0.0003609 0.2        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_16 row_16_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.2          4.29e-05 0.2         4.3e-05 0            4.39e-05 0           4.4e-05 0.2          4.49e-05 0.2         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0           0.0001229 0          0.000123 0           0.0001239 0          0.000124 1.5         0.0001249 1.5        0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.2         0.0002029 0.2        0.000203 0           0.0002039 0          0.000204 0.2         0.0002049 0.2        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 1.5         0.0002829 1.5        0.000283 0           0.0002839 0          0.000284 0           0.0002849 0          0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.2         0.0003629 0.2        0.000363 0           0.0003639 0          0.000364 0.2         0.0003649 0.2        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_17 row_17_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_18 row_18_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_19 row_19_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_20 row_20_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_21 row_21_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_22 row_22_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_23 row_23_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_24 row_24_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_25 row_25_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_26 row_26_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_27 row_27_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_28 row_28_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_29 row_29_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.2          4.69e-05 0.2         4.7e-05 0            4.79e-05 0           4.8e-05 0.2          4.89e-05 0.2         4.9e-05 0            4.99e-05 0           5e-05 0.2            5.09e-05 0.2         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.2          6.49e-05 0.2         6.5e-05 0            6.59e-05 0           6.6e-05 0.2          6.69e-05 0.2         6.7e-05 0            6.79e-05 0           6.8e-05 0.2          6.89e-05 0.2         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0           0.0001269 0          0.000127 0           0.0001279 0          0.000128 1.5         0.0001289 1.5        0.000129 0           0.0001299 0          0.00013 0            0.0001309 0          0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 1.5         0.0001449 1.5        0.000145 0           0.0001459 0          0.000146 0           0.0001469 0          0.000147 0           0.0001479 0          0.000148 1.5         0.0001489 1.5        0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.2         0.0002069 0.2        0.000207 0           0.0002079 0          0.000208 0.2         0.0002089 0.2        0.000209 0           0.0002099 0          0.00021 0.2          0.0002109 0.2        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.2         0.0002249 0.2        0.000225 0           0.0002259 0          0.000226 0.2         0.0002269 0.2        0.000227 0           0.0002279 0          0.000228 0.2         0.0002289 0.2        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 1.5         0.0002869 1.5        0.000287 0           0.0002879 0          0.000288 0           0.0002889 0          0.000289 0           0.0002899 0          0.00029 1.5          0.0002909 1.5        0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0           0.0003049 0          0.000305 0           0.0003059 0          0.000306 1.5         0.0003069 1.5        0.000307 0           0.0003079 0          0.000308 0           0.0003089 0          0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.2         0.0003669 0.2        0.000367 0           0.0003679 0          0.000368 0.2         0.0003689 0.2        0.000369 0           0.0003699 0          0.00037 0.2          0.0003709 0.2        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.2         0.0003849 0.2        0.000385 0           0.0003859 0          0.000386 0.2         0.0003869 0.2        0.000387 0           0.0003879 0          0.000388 0.2         0.0003889 0.2        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_30 row_30_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.2          5.29e-05 0.2         5.3e-05 0            5.39e-05 0           5.4e-05 0.2          5.49e-05 0.2         5.5e-05 0            5.59e-05 0           5.6e-05 0.2          5.69e-05 0.2         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.2            7.09e-05 0.2         7.1e-05 0            7.19e-05 0           7.2e-05 0.2          7.29e-05 0.2         7.3e-05 0            7.39e-05 0           7.4e-05 0.2          7.49e-05 0.2         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 1.5         0.0001329 1.5        0.000133 0           0.0001339 0          0.000134 0           0.0001349 0          0.000135 0           0.0001359 0          0.000136 1.5         0.0001369 1.5        0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0            0.0001509 0          0.000151 0           0.0001519 0          0.000152 1.5         0.0001529 1.5        0.000153 0           0.0001539 0          0.000154 0           0.0001549 0          0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.2         0.0002129 0.2        0.000213 0           0.0002139 0          0.000214 0.2         0.0002149 0.2        0.000215 0           0.0002159 0          0.000216 0.2         0.0002169 0.2        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.2          0.0002309 0.2        0.000231 0           0.0002319 0          0.000232 0.2         0.0002329 0.2        0.000233 0           0.0002339 0          0.000234 0.2         0.0002349 0.2        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0           0.0002929 0          0.000293 0           0.0002939 0          0.000294 1.5         0.0002949 1.5        0.000295 0           0.0002959 0          0.000296 0           0.0002969 0          0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 1.5          0.0003109 1.5        0.000311 0           0.0003119 0          0.000312 0           0.0003129 0          0.000313 0           0.0003139 0          0.000314 1.5         0.0003149 1.5        0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.2         0.0003729 0.2        0.000373 0           0.0003739 0          0.000374 0.2         0.0003749 0.2        0.000375 0           0.0003759 0          0.000376 0.2         0.0003769 0.2        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.2          0.0003909 0.2        0.000391 0           0.0003919 0          0.000392 0.2         0.0003929 0.2        0.000393 0           0.0003939 0          0.000394 0.2         0.0003949 0.2        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vrow_31 row_31_0 0 PWLZ(0 0                  9e-07 0              1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.2          5.89e-05 0.2         5.9e-05 0            5.99e-05 0           6e-05 0.2            6.09e-05 0.2         6.1e-05 0            6.19e-05 0           6.2e-05 0.2          6.29e-05 0.2         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.2          7.69e-05 0.2         7.7e-05 0            7.79e-05 0           7.8e-05 0.2          7.89e-05 0.2         7.9e-05 0            7.99e-05 0           8e-05 0.2            8.09e-05 0.2         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0           0.0001389 0          0.000139 0           0.0001399 0          0.00014 1.5          0.0001409 1.5        0.000141 0           0.0001419 0          0.000142 0           0.0001429 0          0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 1.5         0.0001569 1.5        0.000157 0           0.0001579 0          0.000158 0           0.0001589 0          0.000159 0           0.0001599 0          0.00016 1.5          0.0001609 1.5        0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.2         0.0002189 0.2        0.000219 0           0.0002199 0          0.00022 0.2          0.0002209 0.2        0.000221 0           0.0002219 0          0.000222 0.2         0.0002229 0.2        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.2         0.0002369 0.2        0.000237 0           0.0002379 0          0.000238 0.2         0.0002389 0.2        0.000239 0           0.0002399 0          0.00024 0.2          0.0002409 0.2        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 1.5         0.0002989 1.5        0.000299 0           0.0002999 0          0.0003 0             0.0003009 0          0.000301 0           0.0003019 0          0.000302 1.5         0.0003029 1.5        0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0           0.0003169 0          0.000317 0           0.0003179 0          0.000318 1.5         0.0003189 1.5        0.000319 0           0.0003199 0          0.00032 0            0.0003209 0          0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.2         0.0003789 0.2        0.000379 0           0.0003799 0          0.00038 0.2          0.0003809 0.2        0.000381 0           0.0003819 0          0.000382 0.2         0.0003829 0.2        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.2         0.0003969 0.2        0.000397 0           0.0003979 0          0.000398 0.2         0.0003989 0.2        0.000399 0           0.0003999 0          0.0004 0.2           0.0004009 0.2        0.000401 0           0.0004019 0         )
Vcol_0 col_0_0 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0              2.9e-06 0            3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0              8.9e-06 0            9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0            1.49e-05 0           1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0            4.69e-05 0           4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0            5.29e-05 0           5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0            5.89e-05 0           5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0            8.29e-05 0           8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 1.5          8.89e-05 1.5         8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0            9.49e-05 0           9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 1.5         0.0001269 1.5        0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0           0.0001329 0          0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 1.5         0.0001389 1.5        0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0           0.0001629 0          0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0           0.0001689 0          0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0           0.0001749 0          0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0           0.0002069 0          0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0           0.0002129 0          0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0           0.0002189 0          0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 1.5         0.0002429 1.5        0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0           0.0002489 0          0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 1.5         0.0002549 1.5        0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0           0.0002869 0          0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 1.5         0.0002929 1.5        0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0           0.0002989 0          0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0           0.0003229 0          0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0           0.0003289 0          0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0           0.0003349 0          0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0           0.0003669 0          0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0           0.0003729 0          0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0           0.0003789 0          0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_1 col_0_1 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0              4.9e-06 0            5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0              1.09e-05 0           1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0            1.69e-05 0           1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0            4.89e-05 0           4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0            5.49e-05 0           5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0              6.09e-05 0           6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 1.5          8.49e-05 1.5         8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0              9.09e-05 0           9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 1.5          9.69e-05 1.5         9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0           0.0001289 0          0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 1.5         0.0001349 1.5        0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0            0.0001409 0          0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0           0.0001649 0          0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0            0.0001709 0          0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0           0.0001769 0          0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0           0.0002089 0          0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0           0.0002149 0          0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0            0.0002209 0          0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0           0.0002449 0          0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 1.5          0.0002509 1.5        0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0           0.0002569 0          0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 1.5         0.0002889 1.5        0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0           0.0002949 0          0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 1.5           0.0003009 1.5        0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0           0.0003249 0          0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0            0.0003309 0          0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0           0.0003369 0          0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0           0.0003689 0          0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0           0.0003749 0          0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0            0.0003809 0          0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_2 col_0_2 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0              6.9e-06 0            7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0            1.29e-05 0           1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0            1.89e-05 0           1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0              5.09e-05 0           5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0            5.69e-05 0           5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0            6.29e-05 0           6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0            8.69e-05 0           8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 1.5          9.29e-05 1.5         9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0            9.89e-05 0           9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 1.5          0.0001309 1.5        0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0           0.0001369 0          0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 1.5         0.0001429 1.5        0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0           0.0001669 0          0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0           0.0001729 0          0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0           0.0001789 0          0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0            0.0002109 0          0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0           0.0002169 0          0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0           0.0002229 0          0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 1.5         0.0002469 1.5        0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0           0.0002529 0          0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 1.5         0.0002589 1.5        0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0            0.0002909 0          0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 1.5         0.0002969 1.5        0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0           0.0003029 0          0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0           0.0003269 0          0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0           0.0003329 0          0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0           0.0003389 0          0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0            0.0003709 0          0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0           0.0003769 0          0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0           0.0003829 0          0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_3 col_0_3 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_4 col_0_4 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_5 col_0_5 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_6 col_0_6 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_7 col_0_7 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_8 col_0_8 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_9 col_0_9 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_10 col_0_10 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_11 col_0_11 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_12 col_0_12 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_13 col_0_13 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_14 col_0_14 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_15 col_0_15 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0            3.89e-05 0           3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0            4.29e-05 0           4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0           0.0001189 0          0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 1.5         0.0001229 1.5        0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0           0.0001989 0          0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0           0.0002029 0          0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 1.5         0.0002789 1.5        0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0           0.0002829 0          0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0           0.0003589 0          0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0           0.0003629 0          0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_16 col_0_16 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0              4.09e-05 0           4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0            4.49e-05 0           4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 1.5          0.0001209 1.5        0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0           0.0001249 0          0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0             0.0002009 0          0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0           0.0002049 0          0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0            0.0002809 0          0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 1.5         0.0002849 1.5        0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0            0.0003609 0          0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0           0.0003649 0          0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_17 col_0_17 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_18 col_0_18 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_19 col_0_19 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_20 col_0_20 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_21 col_0_21 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_22 col_0_22 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_23 col_0_23 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_24 col_0_24 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_25 col_0_25 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_26 col_0_26 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_27 col_0_27 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_28 col_0_28 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_29 col_0_29 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0              2.09e-05 0           2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0            2.69e-05 0           2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0            3.29e-05 0           3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0            6.49e-05 0           6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0              7.09e-05 0           7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0            7.69e-05 0           7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 1.5           0.0001009 1.5        0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0           0.0001069 0          0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 1.5         0.0001129 1.5        0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0           0.0001449 0          0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 1.5          0.0001509 1.5        0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0           0.0001569 0          0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0            0.0001809 0          0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0           0.0001869 0          0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0           0.0001929 0          0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0           0.0002249 0          0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0            0.0002309 0          0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0           0.0002369 0          0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0            0.0002609 0          0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 1.5         0.0002669 1.5        0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0           0.0002729 0          0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 1.5         0.0003049 1.5        0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0            0.0003109 0          0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 1.5         0.0003169 1.5        0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0            0.0003409 0          0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0           0.0003469 0          0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0           0.0003529 0          0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0           0.0003849 0          0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0            0.0003909 0          0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0           0.0003969 0          0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_30 col_0_30 0 PWLZ(0 0.0                9e-07 0.0            1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0            2.29e-05 0           2.3e-05 0            2.39e-05 0           2.4e-05 0.1          2.49e-05 0.1         2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0            2.89e-05 0           2.9e-05 0            2.99e-05 0           3e-05 0.1            3.09e-05 0.1         3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0            3.49e-05 0           3.5e-05 0            3.59e-05 0           3.6e-05 0.1          3.69e-05 0.1         3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0            6.69e-05 0           6.7e-05 0            6.79e-05 0           6.8e-05 0.1          6.89e-05 0.1         6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0            7.29e-05 0           7.3e-05 0            7.39e-05 0           7.4e-05 0.1          7.49e-05 0.1         7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0            7.89e-05 0           7.9e-05 0            7.99e-05 0           8e-05 0.1            8.09e-05 0.1         8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0           0.0001029 0          0.000103 0           0.0001039 0          0.000104 0.75        0.0001049 0.75       0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 1.5         0.0001089 1.5        0.000109 0           0.0001099 0          0.00011 0.75         0.0001109 0.75       0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0           0.0001149 0          0.000115 0           0.0001159 0          0.000116 0.75        0.0001169 0.75       0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 1.5         0.0001469 1.5        0.000147 0           0.0001479 0          0.000148 0.75        0.0001489 0.75       0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0           0.0001529 0          0.000153 0           0.0001539 0          0.000154 0.75        0.0001549 0.75       0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 1.5         0.0001589 1.5        0.000159 0           0.0001599 0          0.00016 0.75         0.0001609 0.75       0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0           0.0001829 0          0.000183 0           0.0001839 0          0.000184 0.1         0.0001849 0.1        0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0           0.0001889 0          0.000189 0           0.0001899 0          0.00019 0.1          0.0001909 0.1        0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0           0.0001949 0          0.000195 0           0.0001959 0          0.000196 0.1         0.0001969 0.1        0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0           0.0002269 0          0.000227 0           0.0002279 0          0.000228 0.1         0.0002289 0.1        0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0           0.0002329 0          0.000233 0           0.0002339 0          0.000234 0.1         0.0002349 0.1        0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0           0.0002389 0          0.000239 0           0.0002399 0          0.00024 0.1          0.0002409 0.1        0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 1.5         0.0002629 1.5        0.000263 0           0.0002639 0          0.000264 0.75        0.0002649 0.75       0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0           0.0002689 0          0.000269 0           0.0002699 0          0.00027 0.75         0.0002709 0.75       0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 1.5         0.0002749 1.5        0.000275 0           0.0002759 0          0.000276 0.75        0.0002769 0.75       0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0           0.0003069 0          0.000307 0           0.0003079 0          0.000308 0.75        0.0003089 0.75       0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 1.5         0.0003129 1.5        0.000313 0           0.0003139 0          0.000314 0.75        0.0003149 0.75       0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0           0.0003189 0          0.000319 0           0.0003199 0          0.00032 0.75         0.0003209 0.75       0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0           0.0003429 0          0.000343 0           0.0003439 0          0.000344 0.1         0.0003449 0.1        0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0           0.0003489 0          0.000349 0           0.0003499 0          0.00035 0.1          0.0003509 0.1        0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0           0.0003549 0          0.000355 0           0.0003559 0          0.000356 0.1         0.0003569 0.1        0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0           0.0003869 0          0.000387 0           0.0003879 0          0.000388 0.1         0.0003889 0.1        0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0           0.0003929 0          0.000393 0           0.0003939 0          0.000394 0.1         0.0003949 0.1        0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0           0.0003989 0          0.000399 0           0.0003999 0          0.0004 0.1           0.0004009 0.1        0.000401 0           0.0004019 0         )
Vcol_31 col_0_31 0 PWLZ(0 0                  9e-07 0              1e-06 0              1.9e-06 0            2e-06 0.1            2.9e-06 0.1          3e-06 0              3.9e-06 0            4e-06 0.1            4.9e-06 0.1          5e-06 0              5.9e-06 0            6e-06 0.1            6.9e-06 0.1          7e-06 0              7.9e-06 0            8e-06 0.1            8.9e-06 0.1          9e-06 0              9.9e-06 0            1e-05 0.1            1.09e-05 0.1         1.1e-05 0            1.19e-05 0           1.2e-05 0.1          1.29e-05 0.1         1.3e-05 0            1.39e-05 0           1.4e-05 0.1          1.49e-05 0.1         1.5e-05 0            1.59e-05 0           1.6e-05 0.1          1.69e-05 0.1         1.7e-05 0            1.79e-05 0           1.8e-05 0.1          1.89e-05 0.1         1.9e-05 0            1.99e-05 0           2e-05 0.1            2.09e-05 0.1         2.1e-05 0            2.19e-05 0           2.2e-05 0.1          2.29e-05 0.1         2.3e-05 0            2.39e-05 0           2.4e-05 0            2.49e-05 0           2.5e-05 0            2.59e-05 0           2.6e-05 0.1          2.69e-05 0.1         2.7e-05 0            2.79e-05 0           2.8e-05 0.1          2.89e-05 0.1         2.9e-05 0            2.99e-05 0           3e-05 0              3.09e-05 0           3.1e-05 0            3.19e-05 0           3.2e-05 0.1          3.29e-05 0.1         3.3e-05 0            3.39e-05 0           3.4e-05 0.1          3.49e-05 0.1         3.5e-05 0            3.59e-05 0           3.6e-05 0            3.69e-05 0           3.7e-05 0            3.79e-05 0           3.8e-05 0.1          3.89e-05 0.1         3.9e-05 0            3.99e-05 0           4e-05 0.1            4.09e-05 0.1         4.1e-05 0            4.19e-05 0           4.2e-05 0.1          4.29e-05 0.1         4.3e-05 0            4.39e-05 0           4.4e-05 0.1          4.49e-05 0.1         4.5e-05 0            4.59e-05 0           4.6e-05 0.1          4.69e-05 0.1         4.7e-05 0            4.79e-05 0           4.8e-05 0.1          4.89e-05 0.1         4.9e-05 0            4.99e-05 0           5e-05 0.1            5.09e-05 0.1         5.1e-05 0            5.19e-05 0           5.2e-05 0.1          5.29e-05 0.1         5.3e-05 0            5.39e-05 0           5.4e-05 0.1          5.49e-05 0.1         5.5e-05 0            5.59e-05 0           5.6e-05 0.1          5.69e-05 0.1         5.7e-05 0            5.79e-05 0           5.8e-05 0.1          5.89e-05 0.1         5.9e-05 0            5.99e-05 0           6e-05 0.1            6.09e-05 0.1         6.1e-05 0            6.19e-05 0           6.2e-05 0.1          6.29e-05 0.1         6.3e-05 0            6.39e-05 0           6.4e-05 0.1          6.49e-05 0.1         6.5e-05 0            6.59e-05 0           6.6e-05 0.1          6.69e-05 0.1         6.7e-05 0            6.79e-05 0           6.8e-05 0            6.89e-05 0           6.9e-05 0            6.99e-05 0           7e-05 0.1            7.09e-05 0.1         7.1e-05 0            7.19e-05 0           7.2e-05 0.1          7.29e-05 0.1         7.3e-05 0            7.39e-05 0           7.4e-05 0            7.49e-05 0           7.5e-05 0            7.59e-05 0           7.6e-05 0.1          7.69e-05 0.1         7.7e-05 0            7.79e-05 0           7.8e-05 0.1          7.89e-05 0.1         7.9e-05 0            7.99e-05 0           8e-05 0              8.09e-05 0           8.1e-05 0            8.19e-05 0           8.2e-05 0.75         8.29e-05 0.75        8.3e-05 0            8.39e-05 0           8.4e-05 0.75         8.49e-05 0.75        8.5e-05 0            8.59e-05 0           8.6e-05 0.75         8.69e-05 0.75        8.7e-05 0            8.79e-05 0           8.8e-05 0.75         8.89e-05 0.75        8.9e-05 0            8.99e-05 0           9e-05 0.75           9.09e-05 0.75        9.1e-05 0            9.19e-05 0           9.2e-05 0.75         9.29e-05 0.75        9.3e-05 0            9.39e-05 0           9.4e-05 0.75         9.49e-05 0.75        9.5e-05 0            9.59e-05 0           9.6e-05 0.75         9.69e-05 0.75        9.7e-05 0            9.79e-05 0           9.8e-05 0.75         9.89e-05 0.75        9.9e-05 0            9.99e-05 0           0.0001 0.75          0.0001009 0.75       0.000101 0           0.0001019 0          0.000102 0.75        0.0001029 0.75       0.000103 0           0.0001039 0          0.000104 1.5         0.0001049 1.5        0.000105 0           0.0001059 0          0.000106 0.75        0.0001069 0.75       0.000107 0           0.0001079 0          0.000108 0.75        0.0001089 0.75       0.000109 0           0.0001099 0          0.00011 0            0.0001109 0          0.000111 0           0.0001119 0          0.000112 0.75        0.0001129 0.75       0.000113 0           0.0001139 0          0.000114 0.75        0.0001149 0.75       0.000115 0           0.0001159 0          0.000116 1.5         0.0001169 1.5        0.000117 0           0.0001179 0          0.000118 0.75        0.0001189 0.75       0.000119 0           0.0001199 0          0.00012 0.75         0.0001209 0.75       0.000121 0           0.0001219 0          0.000122 0.75        0.0001229 0.75       0.000123 0           0.0001239 0          0.000124 0.75        0.0001249 0.75       0.000125 0           0.0001259 0          0.000126 0.75        0.0001269 0.75       0.000127 0           0.0001279 0          0.000128 0.75        0.0001289 0.75       0.000129 0           0.0001299 0          0.00013 0.75         0.0001309 0.75       0.000131 0           0.0001319 0          0.000132 0.75        0.0001329 0.75       0.000133 0           0.0001339 0          0.000134 0.75        0.0001349 0.75       0.000135 0           0.0001359 0          0.000136 0.75        0.0001369 0.75       0.000137 0           0.0001379 0          0.000138 0.75        0.0001389 0.75       0.000139 0           0.0001399 0          0.00014 0.75         0.0001409 0.75       0.000141 0           0.0001419 0          0.000142 0.75        0.0001429 0.75       0.000143 0           0.0001439 0          0.000144 0.75        0.0001449 0.75       0.000145 0           0.0001459 0          0.000146 0.75        0.0001469 0.75       0.000147 0           0.0001479 0          0.000148 0           0.0001489 0          0.000149 0           0.0001499 0          0.00015 0.75         0.0001509 0.75       0.000151 0           0.0001519 0          0.000152 0.75        0.0001529 0.75       0.000153 0           0.0001539 0          0.000154 1.5         0.0001549 1.5        0.000155 0           0.0001559 0          0.000156 0.75        0.0001569 0.75       0.000157 0           0.0001579 0          0.000158 0.75        0.0001589 0.75       0.000159 0           0.0001599 0          0.00016 0            0.0001609 0          0.000161 0           0.0001619 0          0.000162 0.1         0.0001629 0.1        0.000163 0           0.0001639 0          0.000164 0.1         0.0001649 0.1        0.000165 0           0.0001659 0          0.000166 0.1         0.0001669 0.1        0.000167 0           0.0001679 0          0.000168 0.1         0.0001689 0.1        0.000169 0           0.0001699 0          0.00017 0.1          0.0001709 0.1        0.000171 0           0.0001719 0          0.000172 0.1         0.0001729 0.1        0.000173 0           0.0001739 0          0.000174 0.1         0.0001749 0.1        0.000175 0           0.0001759 0          0.000176 0.1         0.0001769 0.1        0.000177 0           0.0001779 0          0.000178 0.1         0.0001789 0.1        0.000179 0           0.0001799 0          0.00018 0.1          0.0001809 0.1        0.000181 0           0.0001819 0          0.000182 0.1         0.0001829 0.1        0.000183 0           0.0001839 0          0.000184 0           0.0001849 0          0.000185 0           0.0001859 0          0.000186 0.1         0.0001869 0.1        0.000187 0           0.0001879 0          0.000188 0.1         0.0001889 0.1        0.000189 0           0.0001899 0          0.00019 0            0.0001909 0          0.000191 0           0.0001919 0          0.000192 0.1         0.0001929 0.1        0.000193 0           0.0001939 0          0.000194 0.1         0.0001949 0.1        0.000195 0           0.0001959 0          0.000196 0           0.0001969 0          0.000197 0           0.0001979 0          0.000198 0.1         0.0001989 0.1        0.000199 0           0.0001999 0          0.0002 0.1           0.0002009 0.1        0.000201 0           0.0002019 0          0.000202 0.1         0.0002029 0.1        0.000203 0           0.0002039 0          0.000204 0.1         0.0002049 0.1        0.000205 0           0.0002059 0          0.000206 0.1         0.0002069 0.1        0.000207 0           0.0002079 0          0.000208 0.1         0.0002089 0.1        0.000209 0           0.0002099 0          0.00021 0.1          0.0002109 0.1        0.000211 0           0.0002119 0          0.000212 0.1         0.0002129 0.1        0.000213 0           0.0002139 0          0.000214 0.1         0.0002149 0.1        0.000215 0           0.0002159 0          0.000216 0.1         0.0002169 0.1        0.000217 0           0.0002179 0          0.000218 0.1         0.0002189 0.1        0.000219 0           0.0002199 0          0.00022 0.1          0.0002209 0.1        0.000221 0           0.0002219 0          0.000222 0.1         0.0002229 0.1        0.000223 0           0.0002239 0          0.000224 0.1         0.0002249 0.1        0.000225 0           0.0002259 0          0.000226 0.1         0.0002269 0.1        0.000227 0           0.0002279 0          0.000228 0           0.0002289 0          0.000229 0           0.0002299 0          0.00023 0.1          0.0002309 0.1        0.000231 0           0.0002319 0          0.000232 0.1         0.0002329 0.1        0.000233 0           0.0002339 0          0.000234 0           0.0002349 0          0.000235 0           0.0002359 0          0.000236 0.1         0.0002369 0.1        0.000237 0           0.0002379 0          0.000238 0.1         0.0002389 0.1        0.000239 0           0.0002399 0          0.00024 0            0.0002409 0          0.000241 0           0.0002419 0          0.000242 0.75        0.0002429 0.75       0.000243 0           0.0002439 0          0.000244 0.75        0.0002449 0.75       0.000245 0           0.0002459 0          0.000246 0.75        0.0002469 0.75       0.000247 0           0.0002479 0          0.000248 0.75        0.0002489 0.75       0.000249 0           0.0002499 0          0.00025 0.75         0.0002509 0.75       0.000251 0           0.0002519 0          0.000252 0.75        0.0002529 0.75       0.000253 0           0.0002539 0          0.000254 0.75        0.0002549 0.75       0.000255 0           0.0002559 0          0.000256 0.75        0.0002569 0.75       0.000257 0           0.0002579 0          0.000258 0.75        0.0002589 0.75       0.000259 0           0.0002599 0          0.00026 0.75         0.0002609 0.75       0.000261 0           0.0002619 0          0.000262 0.75        0.0002629 0.75       0.000263 0           0.0002639 0          0.000264 0           0.0002649 0          0.000265 0           0.0002659 0          0.000266 0.75        0.0002669 0.75       0.000267 0           0.0002679 0          0.000268 0.75        0.0002689 0.75       0.000269 0           0.0002699 0          0.00027 1.5          0.0002709 1.5        0.000271 0           0.0002719 0          0.000272 0.75        0.0002729 0.75       0.000273 0           0.0002739 0          0.000274 0.75        0.0002749 0.75       0.000275 0           0.0002759 0          0.000276 0           0.0002769 0          0.000277 0           0.0002779 0          0.000278 0.75        0.0002789 0.75       0.000279 0           0.0002799 0          0.00028 0.75         0.0002809 0.75       0.000281 0           0.0002819 0          0.000282 0.75        0.0002829 0.75       0.000283 0           0.0002839 0          0.000284 0.75        0.0002849 0.75       0.000285 0           0.0002859 0          0.000286 0.75        0.0002869 0.75       0.000287 0           0.0002879 0          0.000288 0.75        0.0002889 0.75       0.000289 0           0.0002899 0          0.00029 0.75         0.0002909 0.75       0.000291 0           0.0002919 0          0.000292 0.75        0.0002929 0.75       0.000293 0           0.0002939 0          0.000294 0.75        0.0002949 0.75       0.000295 0           0.0002959 0          0.000296 0.75        0.0002969 0.75       0.000297 0           0.0002979 0          0.000298 0.75        0.0002989 0.75       0.000299 0           0.0002999 0          0.0003 0.75          0.0003009 0.75       0.000301 0           0.0003019 0          0.000302 0.75        0.0003029 0.75       0.000303 0           0.0003039 0          0.000304 0.75        0.0003049 0.75       0.000305 0           0.0003059 0          0.000306 0.75        0.0003069 0.75       0.000307 0           0.0003079 0          0.000308 1.5         0.0003089 1.5        0.000309 0           0.0003099 0          0.00031 0.75         0.0003109 0.75       0.000311 0           0.0003119 0          0.000312 0.75        0.0003129 0.75       0.000313 0           0.0003139 0          0.000314 0           0.0003149 0          0.000315 0           0.0003159 0          0.000316 0.75        0.0003169 0.75       0.000317 0           0.0003179 0          0.000318 0.75        0.0003189 0.75       0.000319 0           0.0003199 0          0.00032 1.5          0.0003209 1.5        0.000321 0           0.0003219 0          0.000322 0.1         0.0003229 0.1        0.000323 0           0.0003239 0          0.000324 0.1         0.0003249 0.1        0.000325 0           0.0003259 0          0.000326 0.1         0.0003269 0.1        0.000327 0           0.0003279 0          0.000328 0.1         0.0003289 0.1        0.000329 0           0.0003299 0          0.00033 0.1          0.0003309 0.1        0.000331 0           0.0003319 0          0.000332 0.1         0.0003329 0.1        0.000333 0           0.0003339 0          0.000334 0.1         0.0003349 0.1        0.000335 0           0.0003359 0          0.000336 0.1         0.0003369 0.1        0.000337 0           0.0003379 0          0.000338 0.1         0.0003389 0.1        0.000339 0           0.0003399 0          0.00034 0.1          0.0003409 0.1        0.000341 0           0.0003419 0          0.000342 0.1         0.0003429 0.1        0.000343 0           0.0003439 0          0.000344 0           0.0003449 0          0.000345 0           0.0003459 0          0.000346 0.1         0.0003469 0.1        0.000347 0           0.0003479 0          0.000348 0.1         0.0003489 0.1        0.000349 0           0.0003499 0          0.00035 0            0.0003509 0          0.000351 0           0.0003519 0          0.000352 0.1         0.0003529 0.1        0.000353 0           0.0003539 0          0.000354 0.1         0.0003549 0.1        0.000355 0           0.0003559 0          0.000356 0           0.0003569 0          0.000357 0           0.0003579 0          0.000358 0.1         0.0003589 0.1        0.000359 0           0.0003599 0          0.00036 0.1          0.0003609 0.1        0.000361 0           0.0003619 0          0.000362 0.1         0.0003629 0.1        0.000363 0           0.0003639 0          0.000364 0.1         0.0003649 0.1        0.000365 0           0.0003659 0          0.000366 0.1         0.0003669 0.1        0.000367 0           0.0003679 0          0.000368 0.1         0.0003689 0.1        0.000369 0           0.0003699 0          0.00037 0.1          0.0003709 0.1        0.000371 0           0.0003719 0          0.000372 0.1         0.0003729 0.1        0.000373 0           0.0003739 0          0.000374 0.1         0.0003749 0.1        0.000375 0           0.0003759 0          0.000376 0.1         0.0003769 0.1        0.000377 0           0.0003779 0          0.000378 0.1         0.0003789 0.1        0.000379 0           0.0003799 0          0.00038 0.1          0.0003809 0.1        0.000381 0           0.0003819 0          0.000382 0.1         0.0003829 0.1        0.000383 0           0.0003839 0          0.000384 0.1         0.0003849 0.1        0.000385 0           0.0003859 0          0.000386 0.1         0.0003869 0.1        0.000387 0           0.0003879 0          0.000388 0           0.0003889 0          0.000389 0           0.0003899 0          0.00039 0.1          0.0003909 0.1        0.000391 0           0.0003919 0          0.000392 0.1         0.0003929 0.1        0.000393 0           0.0003939 0          0.000394 0           0.0003949 0          0.000395 0           0.0003959 0          0.000396 0.1         0.0003969 0.1        0.000397 0           0.0003979 0          0.000398 0.1         0.0003989 0.1        0.000399 0           0.0003999 0          0.0004 0             0.0004009 0          0.000401 0           0.0004019 0         )

** Transient analysis **
.tran 1e-07 0.000402

.end
